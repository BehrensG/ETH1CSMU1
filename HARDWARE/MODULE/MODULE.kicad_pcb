# Repository BehrensG/ETH1CSMU1 (continued)

## KiCad design HARDWARE/BASE/BASE.kicad_pcb (continued)

Parts:
C501, C502: 8p; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C503, C504: 2u2; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C505, C507, C508, C509, C510, C511, C512, C513, C514, C515, C516, C517, C518, C519, C520, C521: 100n; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C506, C522: 1u; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
D501: RED; LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder
D502: GREEN; LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder
D503: BLUE; LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder
FB501: 742792031; L_0805_2012Metric_Pad1.15x1.40mm_HandSolder
J501: Conn_02x01; PinHeader_1x02_P2.54mm_Vertical
J502: 20021111-00010T4LF; PinHeader_2x05_P1.27mm_Vertical
R501, R503: 680; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R502: 560; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R504, R505, R506: 10k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R507, R508, R509, R510: 4k7; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
U501: STM32H743ZI; TQFP-144_20x20mm_P0.5mm
U502: HDC1080; Texas_PWSON-N6
U503: 24LC08B-E/MS; MSOP-8_3x3mm_P0.65mm
Y501: NX3225GD-8MHZ; NX3225GD

Connections:
/Connector/CXN_REL1: U501.96 (PC6,TIM3_CH1,TIM8_CH1,I2S2_MCK,DFSDM1_C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); also elsewhere on the board
/Connector/CXN_REL2: U501.97 (PC7,TIM3_CH2,TIM8_CH2,I2S3_MCK,DFSDM1_D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); also elsewhere on the board
/Connector/CXN_REL3: U501.98 (PC8,TRACED1,TIM3_CH3,TIM8_CH3,UART5_RTS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); also elsewhere on the board
/Connector/CXN_REL4: U501.101 (PA9,TIM1_CH2,I2C3_SMBA,SPI2_SCK,I2S2_CK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); also elsewhere on the board
/Connector/CXN_REL5: U501.102 (PA10,TIM1_CH3,USART1_RX,LCD_B4,OTG_FS_I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); also elsewhere on the board
/Control/ADC_HP_MISO: U501.4 (PE5,TRACED2,TIM9_CH1,SPI4_MISO,SAI1_SCK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); also elsewhere on the board
/Control/ADC_HP_MOSI: U501.5 (PE6,TRACED3,TIM1_BKIN2,TIM9_CH2,SPI4_MO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); also elsewhere on the board
/Control/ADC_HP_SCLK: U501.1 (PE2,TRACECLK,SPI4_SCK,SAI1_MCLK_A,QUADS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); also elsewhere on the board
/Control/ADC_HP_~CS: U501.3 (PE4,TRACED1,SPI4_NSS,SAI1_FS_A,DFSDM1_D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); also elsewhere on the board
/Control/ADC_HS_MISO: U501.112 (PC11,DFSDM1_DATIN5,SPI3_MISO,USART3_RX,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); also elsewhere on the board
/Control/ADC_HS_MOSI: U501.113 (PC12,TRACED3,SPI3_MOSI,I2S3_SD,USART3_C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); also elsewhere on the board
/Control/ADC_HS_RVS1: U501.29 (PC3,DFSDM1_DATIN1,SPI2_MOSI,I2S2_SD,OTG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); also elsewhere on the board
/Control/ADC_HS_RVS2: U501.28 (PC2,DFSDM1_CKIN1,SPI2_MISO,DFSDM1_CKOUT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); also elsewhere on the board
/Control/ADC_HS_SCLK: U501.111 (PC10,DFSDM1_CKIN5,SPI3_SCK,I2S3_CK,USAR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); also elsewhere on the board
/Control/ADC_HS_~CS: U501.110 (PA15,JTDI,TIM2_CH1,TIM2_ETR,HDMI_CEC,SP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); also elsewhere on the board
/Control/DAC_MISO: U501.75 (PB14,TIM1_CH2N,TIM8_CH2N,USART1_TX,SPI2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); also elsewhere on the board
/Control/DAC_MOSI: U501.76 (PB15,RTC_REFIN,TIM1_CH3N,TIM8_CH3N,USAR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); also elsewhere on the board
/Control/DAC_SCLK: U501.74 (PB13,TIM1_CH1N,SPI2_SCK,I2S2_CK,DFSDM1_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); also elsewhere on the board
/Control/DAC_~CS: U501.73 (PB12,TIM1_BKIN,I2C2_SMBA,SPI2_NSS,I2S2_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); also elsewhere on the board
/Ethernet/NRST: C505.1, J502.10, R504.2, U501.25 (NRST); also elsewhere on the board
/Ethernet/REF_CLK: U501.35 (PA1,TIM2_CH2,TIM5_CH2,UART2_RTS,UART4_R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); also elsewhere on the board
/Ethernet/RMII_CRS_DV: U501.43 (PA7,TIM1_CH1N,TIM3_CH2,TIM8_CH1N,SPI1_M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); also elsewhere on the board
/Ethernet/RMII_MDC: U501.27 (PC1,TRACED0,_DFSDM1_DATIN0,SPI2_MOSI,I2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); also elsewhere on the board
/Ethernet/RMII_MDIO: U501.36 (PA2,TIM2_CH3,TIM5_CH3,TIM9_CH1,USART2_T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); also elsewhere on the board
/Ethernet/RMII_RXD0: U501.44 (PC4,DFSDM1_CKIN2,I2S1_MCK,SPDIF_RX2,ETH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); also elsewhere on the board
/Ethernet/RMII_RXD1: U501.45 (PC5,DFSDM1_DATIN2,SPDIF_RX3,ETH_MII_RXD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); also elsewhere on the board
/Ethernet/RMII_TXD0: U501.128 (PG13,TRACED0,LPTIM1_OUT,SPI6_SCK,USART6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); also elsewhere on the board
/Ethernet/RMII_TXD1: U501.129 (PG14,TRACED1,LPTIM1_ETR,SPI6_MOSI,USART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); also elsewhere on the board
/Ethernet/RMII_TXEN: U501.126 (PG11,SPI1_SCK,I2S1_CK,SPDIF_RX0,SDMMC2_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); also elsewhere on the board
/Function generator/MCU_MISO: U501.20 (PF8,SPI5_MISO,SAI1_SCK_B,UART7_RTS,TIM1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); also elsewhere on the board
/Function generator/MCU_MOSI: U501.21 (PF9,SPI5_MOSI,SAI1_FS_B,UART7_CTS,TIM14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); also elsewhere on the board
/Function generator/MCU_NSS: U501.18 (PF6,TIM10_CH1,SPI5_NSS,SAI1_SD_B,UART7_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); also elsewhere on the board
/Function generator/MCU_SCLK: U501.19 (PF7,TIM11_CH1,SPI5_SCK,SAI1_MCLK_B,UART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); also elsewhere on the board
/GPIO/MCU_~ICLAMP: U501.46 (PB0,TIM1_CH2N,TIM3_CH3,TIM8_CH2N,DFSDM1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); also elsewhere on the board
/MCU/A0: U501.10 (PF0,I2C2_SDA,FMC_A0,EVENTOUT); also elsewhere on the board
/MCU/A1: U501.11 (PF1,I2C2_SCL,FMC_A1,EVENTOUT); also elsewhere on the board
/MCU/A2: U501.12 (PF2,I2C2_SMBA,FMC_A2,EVENTOUT); also elsewhere on the board
/MCU/A3: U501.13 (PF3,FMC_A3,EVENTOUT,ADC3_IN9); also elsewhere on the board
/MCU/A4: U501.14 (PF4,FMC_A4,EVENTOUT,ADC3_IN14); also elsewhere on the board
/MCU/A5: U501.15 (PF5,FMC_A5,EVENTOUT,ADC3_IN15); also elsewhere on the board
/MCU/A6: U501.50 (PF12,FMC_A6,EVENTOUT); also elsewhere on the board
/MCU/A7: U501.53 (PF13,I2C4_SMBA,DFSDM1_DATIN6,FMC_A7,EVE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); also elsewhere on the board
/MCU/A8: U501.54 (PF14,I2C4_SCL,DFSDM1_CKIN6,FMC_A8,EVENT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); also elsewhere on the board
/MCU/A9: U501.55 (PF15,I2C4_SDA,FMC_A9,EVENTOUT); also elsewhere on the board
/MCU/A10: U501.56 (PG0,FMC_A10,EVENTOUT); also elsewhere on the board
/MCU/A11: U501.57 (PG1,FMC_A11,EVENTOUT); also elsewhere on the board
/MCU/A12: U501.87 (PG2,FMC_A12,EVENTOUT); also elsewhere on the board
/MCU/BA0: U501.89 (PG4,FMC_A14,FMC_BA0,EVENTOUT); also elsewhere on the board
/MCU/BA1: U501.90 (PG5,FMC_A15,FMC_BA1,EVENTOUT); also elsewhere on the board
/MCU/CKE: U501.135 (PB5,UART5_RX,TIM3_CH2,I2C1_SMBA,SPI1_MO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); also elsewhere on the board
/MCU/CLK: U501.93 (PG8,SPI6_NSS,SPDIF_RX2,USART6_RTS,ETH_P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); also elsewhere on the board
/MCU/D0: U501.85 (PD14,TIM4_CH3,UART8_CTS,FMC_D0,EVENTOUT); also elsewhere on the board
/MCU/D1: U501.86 (PD15,TIM4_CH4,UART8_RTS,FMC_D1,EVENTOUT); also elsewhere on the board
/MCU/D2: U501.114 (PD0,DFSDM1_CKIN6,DFSDM1_DATIN7,UART4_RX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); also elsewhere on the board
/MCU/D3: U501.115 (PD1,DFSDM1_DATIN6,DFSDM1_CKIN7,UART4_TX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); also elsewhere on the board
/MCU/D4: U501.58 (PE7,TIM1_ETR,DFSDM1_DATIN2,UART7_RX,QUA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); also elsewhere on the board
/MCU/D5: U501.59 (PE8,TIM1_CH1N,DFSDM1_CKIN2,UART7_TX,QUA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); also elsewhere on the board
/MCU/D6: U501.60 (PE9,TIM1_CH1,DFSDM1_CKOUT,UART7_RTS,QUA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); also elsewhere on the board
/MCU/D7: U501.63 (PE10,TIM1_CH2N,DFSDM1_DATIN4,UART7_CTS,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); also elsewhere on the board
/MCU/D8: U501.64 (PE11,TIM1_CH2,SPI4_NSS,DFSDM1_CKIN4,SAI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); also elsewhere on the board
/MCU/D9: U501.65 (PE12,TIM1_CH3N,SPI4_SCK,DFSDM1_DATIN5,S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); also elsewhere on the board
/MCU/D10: U501.66 (PE13,TIM1_CH3,SPI4_MISO,DFSDM1_CKIN5,SA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); also elsewhere on the board
/MCU/D11: U501.67 (PE14,TIM1_CH4,SPI4_MOSI,SAI2_MCLK_B,FMC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); also elsewhere on the board
/MCU/D12: U501.68 (PE15,TIM1_BKIN,FMC_D12,LCD_R7,EVENTOUT); also elsewhere on the board
/MCU/D13: U501.77 (PD8,DFSDM1_CKIN3,USART3_TX,SPDIF_RX1,FM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); also elsewhere on the board
/MCU/D14: U501.78 (PD9,DFSDM1_DATIN3,USART3_RX,FMC_D14,EVE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); also elsewhere on the board
/MCU/D15: U501.79 (PD10,DFSDM1_CKOUT,USART3_CK,FMC_D15,LCD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); also elsewhere on the board
/MCU/EEPROM_SCL: R510.2, U501.81 (PD12,TIM4_CH1,LPTIM1_IN1,I2C4_SCL,USART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), U503.6 (SCL)
/MCU/EEPROM_SDA: R509.2, U501.82 (PD13,TIM4_CH2,LPTIM1_OUT,I2C4_SDA,QUADS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), U503.5 (SDA)
/MCU/EEPROM_WP: U501.80 (PD11,I2C4_SMBA,USART3_CTS,QUADSPI_BK1_I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), U503.7 (WP)
/MCU/LDQM: U501.141 (PE0,TIM4_ETR,LPTIM1_ETR,UART8_RX,SAI2_M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); also elsewhere on the board
/MCU/MCU_DEFAULT: J501.1, R506.1, U501.34 (PA0,TIM2_CH1,TIM2_ETR,TIM5_CH1,TIM8_ETR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)
/MCU/MCU_VDDA: C522.1, FB501.1, U501.32 (VREF+), U501.33 (VDDA)
/MCU/SENS_SCL: R507.2, U501.100 (PA8,MCO1,TIM1_CH1,TIM8_BKIN2,I2C3_SCL,U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), U502.6 (SCL)
/MCU/SENS_SDA: R508.2, U501.99 (PC9,MCO2,TIM3_CH4,TIM8_CH4,I2C3_SDA,I2S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), U502.1 (SDA)
/MCU/SPI1_MISO: U501.42 (PA6,TIM1_BKIN,TIM3_CH1,TIM8_BKIN,SPI1_M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); also elsewhere on the board
/MCU/SPI1_MOSI: U501.123 (PD7,DFSDM1_DATIN4,SPI1_MOSI,I2S1_SD,DFS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); also elsewhere on the board
/MCU/SPI1_NSS: U501.40 (PA4,SPI1_NSS,I2S1_WS,SPI3_NSS,I2S3_WS,U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); also elsewhere on the board
/MCU/SPI1_SCK: U501.41 (PA5,TIM2_CH1,TIM2_ETR,TIM8_CH1N,SPI1_SC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); also elsewhere on the board
/MCU/TCK_SWCLK: J502.4, U501.109 (PA14,JTCK-SWCLK,EVENTOUT)
/MCU/TMS_SWDIO: J502.2, U501.105 (PA13,JTMS-SWDIO,EVENTOUT)
/MCU/TRIG_EN: U501.92 (PG7,SAI1_MCLK_A,USART6_CK,FMC_INT,DCMI_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); also elsewhere on the board
/MCU/TRIG_IN: U501.88 (PG3,FMC_A13,EVENTOUT); also elsewhere on the board
/MCU/TRIG_OUT: U501.91 (PG6,FMC_NE3,DCMI_D12,LCD_R7,EVENTOUT); also elsewhere on the board
/MCU/UDQM: U501.142 (PE1,LPTIM1_IN2,UART8_TX,FMC_NBL1,DCMI_D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); also elsewhere on the board
/MCU/~CAS: U501.132 (PG15,USART6_CTS,FMC_SDNCAS,DCMI_D13,EVE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); also elsewhere on the board
/MCU/~CS: U501.136 (PB6,UART5_TX,TIM4_CH1,HDMI_CEC,I2C1_SCL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); also elsewhere on the board
/MCU/~RAS: U501.49 (PF11,SPI5_MOSI,SAI2_SD_B,FMC_SDNRAS,_DC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); also elsewhere on the board
/MCU/~WE: U501.26 (PC0,DFSDM1_CKIN0,DFSDM1_DATIN4,SAI2_FS_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); also elsewhere on the board
unnamed: C501.1, U501.23 (PH0,EVENTOUT,OSC_IN), Y501.1
unnamed: C502.1, U501.24 (PH1,EVENTOUT,OSC_OUT), Y501.2
unnamed: C503.1, U501.71 (VCAP_1)
unnamed: C504.1, U501.106 (VCAP_2)
unnamed: D501.1 (K), R501.2
unnamed: D502.1 (K), R502.2
unnamed: D503.1 (K), R503.2
unnamed: R501.1, U501.7 (PC13,EVENTOUT,RTC_TAMP2,RTC_TS,WKUP5)
unnamed: R502.1, U501.8 (PC14,EVENTOUT,OSC32_IN)
unnamed: R503.1, U501.9 (PC15,EVENTOUT,OSC32_OUT)
unnamed: R505.1, U501.138 (BOOT0)

Parts:
C601: 1u; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
J601: C64AC; Socket_DIN41612-CaseC1-AC-Male-64Pin-2rows
K601, K602, K603, K604, K605: HE3621A0510; HE360_x-5050462-8
U601: ULN2003A; TSSOP-16_4.4x5mm_P0.65mm

Connections:
+24V: J601.A31 (31A), J601.A32 (32A), J601.C31 (31C), J601.C32 (32C); also elsewhere on the board
/Analog/+GUA: K603.1; also elsewhere on the board
/Analog/+OUT: K601.1; also elsewhere on the board
/Analog/+SEN: K604.1; also elsewhere on the board
/Analog/-SEN: K605.1; also elsewhere on the board
/Connector/A: J601.A2 (2A), J601.C2 (2C), K601.4
/Connector/B: J601.A3 (3A), J601.C3 (3C), K602.4
/Connector/C: J601.A4 (4A), J601.C4 (4C), K603.4
/Connector/CXN_REL1: U601.5 (I5); also elsewhere on the board
/Connector/CXN_REL2: U601.4 (I4); also elsewhere on the board
/Connector/CXN_REL3: U601.3 (I3); also elsewhere on the board
/Connector/CXN_REL4: U601.2 (I2); also elsewhere on the board
/Connector/CXN_REL5: U601.1 (I1); also elsewhere on the board
/Connector/D: J601.A5 (5A), J601.C5 (5C)
/Connector/E: J601.A6 (6A), J601.C6 (6C), K604.4
/Connector/EXT_TRIG: J601.A16 (16A); also elsewhere on the board
/Connector/F: J601.A7 (7A), J601.C7 (7C), K605.4
/Connector/RX+: J601.A20 (20A); also elsewhere on the board
/Connector/RX-: J601.A21 (21A); also elsewhere on the board
/Connector/TX+: J601.C20 (20C); also elsewhere on the board
/Connector/TX-: J601.C21 (21C); also elsewhere on the board
Earth: J601.A18 (18A), J601.A22 (22A), J601.C18 (18C), J601.C22 (22C); also elsewhere on the board
GNDPWR: J601.A27 (27A), J601.A28 (28A), J601.C27 (27C), J601.C28 (28C); also elsewhere on the board
GND_TRIG: J601.C16 (16C); also elsewhere on the board
unnamed: K601.3, U601.12 (O5)
unnamed: K602.3, U601.13 (O4)
unnamed: K603.3, U601.14 (O3)
unnamed: K604.3, U601.15 (O2)
unnamed: K605.3, U601.16 (O1)
OCOM: K602.1; also elsewhere on the board

Parts:
C701, C704: 330p/2kV; C_1210_3225Metric_Pad1.33x2.70mm_HandSolder
C702, C703: 4u7/50V; C_1206_3216Metric_Pad1.33x1.80mm_HandSolder
D701: MMSZ5249B; D_SOD-123
D702: SM6T30AY; DO_214AA_REV
D703: RED; LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder
F701: MF-LSMF185/33X; Fuse_SMD2920
HS701: Heatsink
L701: 7448014501
Q701: IRFR5410; TO-252-2_Rectifier
R701: 100k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R702, R704: OPT; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R703: 370; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
U701: MAX5902; SOT-23-6_Handsoldering
U702: THL15-2415WI; THL15

Connections:
+24V: F701.2; also elsewhere on the board
+24VF: C701.1, R702.1, U702.3 (+VOUT); also elsewhere on the board
GNDPWR: C702.2, C703.2, D702.2 (A), D703.1 (K), L701.1, U701.4 (GND); also elsewhere on the board
unnamed: C701.2, L701.3, U702.1 (+VIN)
unnamed: C702.1, C703.1, D701.1 (K), L701.2, Q701.2 (D), U701.2 (DRAIN)
unnamed: C704.2, L701.4, U702.2 (-VIN)
unnamed: D701.2 (A), R703.1
unnamed: D702.1 (K), F701.1, Q701.3 (S), R701.1, U701.1 (VS)
unnamed: D703.2 (A), R703.2
unnamed: Q701.1 (G), U701.3 (GATE)
unnamed: R701.2, U701.6 (ON/~OFF)
unnamed: R702.2, R704.1, U702.4 (TRIM)

Parts:
C801, C813: 1u/HC; C_1206_3216Metric_Pad1.33x1.80mm_HandSolder
C802, C808, C809, C814, C817, C818: 10u/50V; C_1206_3216Metric_Pad1.33x1.80mm_HandSolder
C803, C805, C806, C807, C815, C821, C822, C823: 4u7/50V; C_1206_3216Metric_Pad1.33x1.80mm_HandSolder
C804, C816: 4p7; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C810, C819: 10u/16V; C_1206_3216Metric_Pad1.33x1.80mm_HandSolder
C811, C820: 47u/16V; C_1206_3216Metric_Pad1.33x1.80mm_HandSolder
C812, C824: 1u; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
D801, D802: PMEG6010EP,115; D_SOD-128
L801, L803: 74489440068
L802, L804: TCK-141
R801, R802, R805, R806: 1M; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R803, R807: 287k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R804: 97k6; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R808: 46k4; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
U801: MC7815BD2TG; TO-263-2
U802: LM1117DTX-5.0/NOPB; TO-252-2
U803: TSR1-2490; TSR1
U804, U808: LT8330_S6; TSOT-23-6_HandSoldering
U805: MC7915BD2TG; TO-263-2
U806: LM1117DTX-3.3/NOPB; TO-252-2
U807: TSR1-2450; TSR1

Connections:
+15V: C807.1, U801.3 (OUT); also elsewhere on the board
+24VF: C802.1, C803.1, C808.1, C814.1, C815.1, C817.1, L801.1, L802.1, L803.1, L804.1, R801.1, R805.1, U804.6 (VIN), U808.6 (VIN); also elsewhere on the board
-15V: C823.1, U805.3 (VO); also elsewhere on the board
unnamed: C801.1, D801.2 (A), L801.2
unnamed: C801.2, L801.4, U804.1 (SW)
unnamed: C804.1, C805.1, C806.1, D801.1 (K), R802.1, U801.1 (IN)
unnamed: C804.2, R802.2, R804.1, U804.3 (FBX)
unnamed: C809.1, L802.2, U803.1 (VI)
unnamed: C810.1, U802.3 (VI), U803.3 (VO)
unnamed: C812.1, U804.5 (INTVCC)
unnamed: C813.1, D802.2 (A), L803.2
unnamed: C813.2, L803.4, U808.1 (SW)
unnamed: C816.1, C821.1, C822.1, L803.3, R806.1, U805.2 (VI)
unnamed: C816.2, R806.2, R808.1, U808.3 (FBX)
unnamed: C818.1, L804.2, U807.1 (VI)
unnamed: C819.1, U806.3 (VI), U807.3 (VO)
unnamed: C824.1, U808.5 (INTVCC)
unnamed: R801.2, R803.1, U804.4 (EN/UVLO)
unnamed: R805.2, R807.1, U808.4 (EN/UVLO)
