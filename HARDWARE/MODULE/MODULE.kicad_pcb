# Repository BehrensG/ETH1CSMU1

## KiCad design HARDWARE/MODULE/MODULE.kicad_pcb

Board: 4 copper layers, 160.0 x 100.0 mm, 119 parts (16 on the bottom side), 62 nets.

Parts:
C301: 4p7; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C302, C315: 1u/50V; C_1206_3216Metric_Pad1.33x1.80mm_HandSolder
C303, C316: 10n/50V; C_1206_3216Metric_Pad1.33x1.80mm_HandSolder
C304, C305, C306, C317, C318, C319, C336, C337: 4u7/50V; C_1206_3216Metric_Pad1.33x1.80mm_HandSolder
C307, C320: 4u7/100V; C_2220_5650Metric_Pad1.97x5.40mm_HandSolder
C308, C309, C310, C311, C312, C321, C322, C323, C324, C325: 22u/100V; C_2220_5650Metric_Pad1.97x5.40mm_HandSolder
C313, C330, C332, C334, C339, C343, C345: 1u; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C314: 0.47u/100V; C_1206_3216Metric_Pad1.33x1.80mm_HandSolder
C326: 47p; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C327, C335, C340, C341: 100n; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C328: 2n2; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C329, C333, C338, C346: 4u7; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C331, C344: 100p/2kV; C_1210_3225Metric_Pad1.33x2.70mm_HandSolder
C342: 10u; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
D201, D204: BAV99LT1; SOT-23
D202, D203: RS1KB-13-F; D_SMA
D301: PMEG6010EP,115; D_SOD-128
D302: DFLS1100; PowerDI-123
D303, D304, D305, D306, D307, D308, D309, D310, D311, D312: MBR0530; D_SOD-123
FB301, FB302: BLM18AG102; L_0603_1608Metric_Pad1.05x0.95mm_HandSolder
H101, H102, H103, H104: MountingHole; MountingHole_3.2mm_M3_DIN965_Pad
HS201, HS202: HSE-B20350-NP
J201: Conn_02x08_Odd_Even; PinSocket_2x08_P2.54mm_Vertical
J301: Conn_02x06_Odd_Even; PinSocket_2x06_P2.54mm_Vertical
L301, L303: 742792040; L_0805_2012Metric_Pad1.15x1.40mm_HandSolder
L302: 74438335068
L304: MSD7342-124; MSD7342
L305: 744273222
L306: SRF0905-202Y; SRF0905
Q201, Q202: 2N7002; SOT-23
Q203: TIP41C/D44H; TO-220-3_Horizontal_TabDown
Q204: MMBT3904; SOT-23
Q205: PZT2907A; SOT-223-3_TabPin2
Q206: PZT2222A; SOT-223-3_TabPin2
Q207: MMBT3906; SOT-23
Q208: TIP42C/D45H; TO-220-3_Horizontal_TabDown
R201, R205: 49k9; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R202, R204: 249; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R203, R212: 2k/1W; R_2512_6332Metric_Pad1.40x3.35mm_HandSolder
R206, R209, R211: 1k; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R207, R210: 24R9/1W; R_2512_6332Metric_Pad1.40x3.35mm_HandSolder
R208: 200; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R301: 240; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R302, R303: 1M; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R304: 6k49; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R305: 287k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R306: 41k7; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R307: 576k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R308: 120; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R309: 481k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R310: 3k24; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R311: 16k2; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R312: 84k5; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
TR301: Wuerth_750315371; Transformer_Wuerth_750315371
U301: LM317_TO-263; TO-263-3_TabPin2
U302: LT8330_S6; TSOT-23-6_HandSoldering
U303: LM337_TO263; TO-263-3_TabPin2
U304: LT8570_MS8E; MSOP-8-1EP_3x3mm_P0.65mm_EP1.68x1.88mm_ThermalVias
U305: L78L15_SO8; SOIC-8_3.9x4.9mm_P1.27mm
U306: TEL10-2415; TEL10
U307: SN6505BDBV; SOT-23-6
U308: L79L15_SO8; SOIC-8_3.9x4.9mm_P1.27mm

Connections:
+5V: J301.7, J301.8, L306.1
+15V: J201.9, J201.10, Q206.2, R201.1, R203.1
+15VF: C335.1, J201.13, U305.1
+24V: C336.1, C337.1, J301.1, J301.2, J301.3, J301.4, L305.1
+24V_HV: C302.1, C303.1, C315.1, C316.1, L301.1, L303.1, U306.9
+HV: C307.1, C308.1, C309.1, C310.1, C311.1, C312.1, D202.1, Q203.2, R301.1, U301.2
-15V: J201.5, J201.6, Q205.2, R205.2, R212.2
-15VF: C340.2, J201.15, U308.1
-HV: C320.1, C321.1, C322.1, C323.1, C324.1, C325.1, D203.2, Q208.2, R308.1, U303.3
/High Voltage Amplifier/100mA: J201.1, J201.2, Q201.1, Q202.1
/High Voltage Amplifier/AMPIN: J201.3, J201.4, R208.2
/High Voltage Amplifier/BASE+: Q204.1, R201.2, R202.1, R206.2
/High Voltage Amplifier/BASE-: Q207.1, R204.2, R205.1, R211.2
/High Voltage Amplifier/FLOAT_COM: D202.2, D203.1, J201.11, J201.12, Q201.2, Q202.3, Q204.2, Q207.2, R207.2, R209.1, R210.1
GND: C336.2, C337.2, J301.9, J301.10, J301.11, J301.12, L305.3, L306.2
GND1: J201.7, J201.8
GNDHV: C302.2, C303.2, C304.2, C305.2, C306.2, C307.2, C308.2, C309.2, C310.2, C311.2, C312.2, C313.2, C315.2, C316.2, C317.2, C318.2, C319.2, C320.2, C321.2, C322.2, C323.2, C324.2, C325.2, C326.2, C327.2, C328.2, C329.1, C331.1, C333.2, C334.2, C335.2, C338.1, C339.1, C340.1, C344.1, C346.2, D302.1, D307.2, D308.1, J201.14, J201.16, R304.2, R305.2, R306.2, R310.2, R312.2, TR301.5, U302.2, U304.8, U304.9, U305.2, U305.3, U305.6, U305.7, U306.10, U308.5
unnamed: C301.1, C305.1, C306.1, D301.1, R303.1, U301.3
unnamed: C301.2, R303.2, R306.1, U302.3
unnamed: C304.1, L301.2, L302.1, R302.1, U302.6
unnamed: C313.1, U302.5
unnamed: C314.1, D302.2, L304.4
unnamed: C314.2, L304.3, U304.4
unnamed: C317.1, L303.2, L304.1, R307.1, U304.3
unnamed: C318.1, C319.1, L304.2, R309.1, U303.2
unnamed: C326.1, R311.1, U304.2
unnamed: C327.1, U304.7
unnamed: C328.1, R311.2
unnamed: C329.2, D303.1, D304.1
unnamed: C330.1, D305.2, D306.1
unnamed: C330.2, C345.2, D304.2, D312.1, TR301.4
unnamed: C331.2, L305.2, U306.16
unnamed: C332.1, D306.2, D307.1
unnamed: C332.2, C343.2, D303.2, D311.1, TR301.6
unnamed: C333.1, D305.1, FB301.2
unnamed: C334.1, FB301.1, U305.8
unnamed: C338.2, D310.2, FB302.2
unnamed: C339.2, FB302.1, U308.2, U308.3, U308.6, U308.7
unnamed: C341.2, C342.2, L306.3, U307.4, U307.6
unnamed: C343.1, D308.2, D309.1
unnamed: C344.2, L305.4, U306.1
unnamed: C345.1, D309.2, D310.1
unnamed: C346.1, D311.2, D312.2
unnamed: D201.1, Q203.1, Q205.3, R203.2
unnamed: D201.3, Q204.3
unnamed: D204.2, Q206.3, Q208.1, R212.1
unnamed: D204.3, Q207.3
unnamed: D301.2, L302.2, U302.1
unnamed: Q201.3, R202.2
unnamed: Q202.2, R204.1
unnamed: Q203.3, R206.1, R207.1
unnamed: Q205.1, Q206.1, R208.1, R209.2
unnamed: Q208.3, R210.2, R211.1
unnamed: R301.2, R304.1, U301.1
unnamed: R302.2, R305.1, U302.4
unnamed: R307.2, U304.5
unnamed: R308.2, R310.1, U303.1
unnamed: R309.2, U304.1
unnamed: R312.1, U304.6
unnamed: TR301.1, U307.1
unnamed: TR301.3, U307.3
VDD: C341.1, C342.1, L306.4, TR301.2, U307.2, U307.5

## KiCad design HARDWARE/BASE/BASE.kicad_pcb

Parts:
H101, H102, H103, H104: MountingHole; MountingHole_3.2mm_M3_DIN965_Pad
M101: 60817-096

Parts:
C201, C203, C204, C206, C208: 100n; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C202, C205, C207: 1u; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C209: 47p; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
D201: SMBJ5.0A; D_SMB
D202: BAV99; SOT-23
D203: SD36C-01FTG; D_SOD-323_HandSoldering
L201: CW252016-R33G; CW252016
R201: 10k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R202: 1k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R203: 14k7; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R204: 100; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R205: 47; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R206: 51R1; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
U201: 74AC125; TSSOP-14_4.4x5mm_P0.65mm
U202: TXB0104PW; TSSOP-14_4.4x5mm_P0.65mm
U203: ADuM5402; SOIC-16W_7.5x10.3mm_P1.27mm

Connections:
+5V_TRIG: C206.1, C207.1, C208.1, R202.1, U201.14 (VCC), U203.10 (VSEL), U203.16 (VISO)
/Connector/EXT_TRIG: C209.1, D203.1 (A1), L201.1; also elsewhere on the board
/MCU/TRIG_EN: U202.2 (A1); also elsewhere on the board
/MCU/TRIG_IN: U202.4 (A3); also elsewhere on the board
/MCU/TRIG_OUT: U202.3 (A2); also elsewhere on the board
/Trigger/EXT_TRIG_SIGN: R203.1, U201.3 (O), U203.12 (VIC)
/Trigger/TRIG_OUT_EN: U201.4 (EN), U201.10 (EN), U201.13 (EN), U203.14 (VOA)
/Trigger/TRIG_OUT_SIGN: U201.5 (D), U201.9 (D), U201.12 (D), U203.13 (VOB)
GND_TRIG: C206.2, C207.2, C208.2, D201.2 (A), D202.1 (K), D203.2 (A2), R206.2, U201.1 (EN), U201.7 (GND), U203.9 (GNDISO), U203.15 (GNDISO); also elsewhere on the board
unnamed: C209.2, R206.1
unnamed: D201.1 (K), D202.2 (A), R202.2
unnamed: D202.3 (K), R204.2, R205.1, U201.6 (O), U201.8 (O), U201.11 (O)
unnamed: L201.2, R205.2
unnamed: R201.2, U202.8 (OE)
unnamed: R203.2, R204.1, U201.2 (D)
unnamed: U202.11 (B3), U203.5 (VOC)
unnamed: U202.12 (B2), U203.4 (VIB)
unnamed: U202.13 (B1), U203.3 (VIA)

Parts:
C401, C402, C404, C405, C406, C407, C410: 100n; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C403, C409: 1u; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C408: 470p; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C411, C412: 1n/1kV; C_1206_3216Metric_Pad1.33x1.80mm_HandSolder
C413, C414: 8p; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
D401: YELLOW; LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder
D402: GREEN; LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder
FB401: 742792031; L_0805_2012Metric_Pad1.15x1.40mm_HandSolder
L401: 749010012A
R401, R402, R403, R404: 49R9; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R405, R406, R408, R412: 33; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R407, R413, R417, R418, R419, R420: 10k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R409: 12k1; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R410, R411: 75/1%; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R414, R415: 270; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R416: 1M/1kV; R_1206_3216Metric_Pad1.30x1.75mm_HandSolder
R421: 1k5; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
U401, U403: LC03-3.3; SO8E
U402: LAN8742A; QFN-24-1EP_4x4mm_P0.5mm_EP2.6x2.6mm_ThermalVias
Y401: NX5032GA-25.000M-LN-CD-1; NX5032GA

Connections:
/Connector/RX+: U403.8; also elsewhere on the board
/Connector/RX-: U403.5; also elsewhere on the board
/Connector/TX+: U401.8; also elsewhere on the board
/Connector/TX-: U401.5; also elsewhere on the board
/Ethernet/ETH_RXN: L401.8 (RD-), R404.2, U402.22 (RXN)
/Ethernet/ETH_RXP: L401.6 (RD+), R403.2, U402.23 (RXP)
/Ethernet/ETH_TXN: L401.3 (TD-), R402.2, U402.20 (TXN)
/Ethernet/ETH_TXP: L401.1 (TD+), R401.2, U402.21 (TXP)
/Ethernet/MODE0: R405.1, R417.2, U402.8 (RXD0/MODE0)
/Ethernet/MODE1: R406.1, R418.2, U402.7 (RXD1/MODE1)
/Ethernet/MODE2: R408.1, R419.2, U402.11 (CRS_DV/MODE2)
/Ethernet/NRST: U402.15 (~RST); also elsewhere on the board
/Ethernet/REFCLK0: R412.1, R420.2, U402.14 (~INT/REFCLK0)
/Ethernet/REF_CLK: R412.2; also elsewhere on the board
/Ethernet/RMII_CRS_DV: R408.2; also elsewhere on the board
/Ethernet/RMII_MDC: U402.13 (MDC); also elsewhere on the board
/Ethernet/RMII_MDIO: R421.2, U402.12 (MDIO); also elsewhere on the board
/Ethernet/RMII_RXD0: R405.2; also elsewhere on the board
/Ethernet/RMII_RXD1: R406.2; also elsewhere on the board
/Ethernet/RMII_TXD0: U402.17 (TXD0); also elsewhere on the board
/Ethernet/RMII_TXD1: U402.18 (TXD1); also elsewhere on the board
/Ethernet/RMII_TXEN: U402.16 (TXEN); also elsewhere on the board
Earth: C411.2, C412.1, R416.1; also elsewhere on the board
unnamed: C408.1, C409.1, U402.6 (VDDCR)
unnamed: C411.1, R410.2, R411.2
unnamed: C413.1, U402.5 (XTAL1/CLKIN), Y401.2
unnamed: C414.1, U402.4 (XTAL2), Y401.1
unnamed: D401.1 (K), R414.1
unnamed: D401.2 (A), R413.1, U402.2 (LED2/~INTSEL)
unnamed: D402.1 (K), R415.1
unnamed: D402.2 (A), U402.3 (LED1/REGOFF)
unnamed: L401.9 (RX-), U403.4
unnamed: L401.10 (CRX), R410.1
unnamed: L401.11 (RX+), U403.1
unnamed: L401.14 (TX-), U401.4
unnamed: L401.15 (CTX), R411.1
unnamed: L401.16 (TX+), U401.1
unnamed: R407.1, U402.10 (RXER/PHYAD0)
unnamed: R409.2, U402.24 (RBIAS)
VCCQ: C403.1, C404.1, C405.1, C406.1, C407.1, C410.1, FB401.1, L401.2 (CTD), L401.7 (CRD), R401.1, R402.1, R403.1, R404.1, U402.1 (VDD2A), U402.19 (VDD1A)
