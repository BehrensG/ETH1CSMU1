# Repository BehrensG/ETH1CSMU1 (continued)

## KiCad design HARDWARE/ETH1CSMU1/ETH1CSMU1.kicad_pcb

Board: 2 copper layers, 160.0 x 100.0 mm, 741 parts (0 on the bottom side), 466 nets, no tracks yet.

Parts:
C201, C208, C301, C303, C502, C504, C601, C608, C703, C904, C1502: 1u; C_0603_Symbol6
C202, C203, C602, C603: 2u2; C_0603_Symbol7
C204, C205, C604, C605: 20p; C_0603
C206, C207, C209, C210, C211, C212, C213, C214, C215, C216, C217, C218, C219, C220, C306, C307, C308, C309, C310, C311, C312, C313, C314, C315, C316, C317, C318, C319, C320, C321, C322, C323, C324, C325, C326, C327, C328, C329, C330, C331, C332, C333, C334, C335, C336, C505, C518, C519, C520, C521, C522, C523, C524, C525, C526, C527, C528, C529, C530, C531, C532, C533, C534, C606, C607, C609, C610, C611, C612, C613, C614, C615, C616, C617, C618, C619, C620, C701, C801, C802, C803, C804, C805, C806, C807, C901, C905, C906, C907, C908, C1101, C1105, C1106, C1107, C1108, C1109, C1110, C1111, C1112, C1113, C1114, C1115, C1116, C1117, C1118, C1119, C1120, C1121, C1122, C1251, C1265, C1301, C1302, C1303, C1304, C1305, C1306, C1307, C1308, C1309, C1310, C1311, C1312, C1313, C1416, C1417, C1418, C1419, C1420, C1421, C1422, C1423, C1501, C1503, C1601, C1602, C1603, C1604, C1605, C1606, C1607: 100n; C_0603_Symbol1
C302, C407, C409, C503, C510, C909, C1102, C1209, C1210, C1211, C1212, C1213, C1215, C1229, C1230, C1231, C1232, C1233, C1235, C1246, C1248, C1257, C1259, C1271, C1273: 10u; C_1206_Symbol1
C304, C401, C403, C406, C1103, C1409, C1410: 15p; C_0603_Symbol5
C305: 10p; C_0603
C402, C405, C506, C507, C702, C1219, C1242: 10n; C_0603_Symbol2
C404: 1n; C_0603
C408, C410: 100u; CP_Tantalum_Case-X_EIA-7343-43_Hand
C501: 1000p; C_0603
C508, C509: 1p5; C_0603
C511, C1415: 150p; C_0603
C512, C1254, C1268, C1406: 100p; C_0603
C513, C1404, C1411: 33p; C_0603
C514: 180p; C_0603
C515: 300p; C_0603
C516: 330p; C_0603
C517, C1408: 270p; C_0603
C704, C705, C706, C707: 82p; C_0603_Symbol3
C808, C1253, C1267: 47p; C_0603
C902, C912, C1221, C1239: 1000p/2kV; C_1206
C903, C1413: 470p; C_0603
C910, C911: 30p; C_0603
C1104: 1n2; C_0603
C1201, C1202, C1220, C1222: 2u2/100V/X7R; C_1206_Symbol3
C1203, C1204, C1205, C1206, C1223, C1224, C1225, C1226, C1238, C1245, C1263: 4u7/50V; C_1210_1
C1207, C1208, C1227, C1228: 47u; CP_Tantalum_Case-X_EIA-7343-43_Hand
C1214, C1216, C1234, C1236, C1247, C1249, C1258, C1260, C1272, C1274: 4u7; C_1206_Symbol2
C1217, C1240, C1243, C1261: 470n; C_0603_Symbol4
C1218, C1241: 4u7/50V/X7R; C_1210_1
C1237, C1244, C1262: 10u/50V; C_1210
C1250, C1264: NC; C_0603
C1252, C1266: 3n3; C_0603
C1255, C1256, C1269, C1270: 47u; C_1210_2
C1401, C1403, C1405: 68p; C_0603
C1402: 8p; C_0603
C1407: 560p; C_0603
C1412: 22p; C_0603
C1414: 39p; C_0603
D301, D302, D303, D305, D307, D308, D309, D310, D311, D312: BAT54-02V; D_SOD-523
D304, D306: BAT54C; SOT-23
D401, D402, D1502, D1504, D1506, D1508: BAV16WS; D_SOD-323_HandSoldering
D701: PESD2CAN; SOT23
D801: SMBJ5.0A; DO_214AA_REV
D802: BAV99; SOT23
D803: SD36C-01FTG; D_SOD-323_HandSoldering
D901: GREEN; LED_0603
D902: YELLOW; LED_0603
D1201: MBRS3100T3G; D_SMC
D1202: VS-30BQ060; D_SMC
D1203: SZMMSZ4705T1; SOD-323F
D1204: SM6T30AY; DO_214AA_REV
D1205: RED; LED_0603
D1206, D1207: SBR3U100LP; U-DFN3030-8
D1301, D1302, D1303, D1304, D1401, D1402, D1403, D1404, D1405, D1406, D1407: BAV16W; D_SOD-323_HandSoldering
D1501, D1503, D1505, D1507: MMSZ5227; D_SOD-123
F1201: MF-LSMF185/33X; Fuse_SMD2920
FB201, FB202, FB601, FB602, FB1001, FB1201, FB1202, FB1203, FB1204, FB1205: MPZ2012S221A; R_0805_Symbol1
J201, J601: Conn_02x05; Pin_Header_Straight_2x05_Pitch1.27mm
J1001: C96ABC; Socket_DIN41612-CaseC1-full-Male-96Pin-3rows
J1301: Conn_01x03; GMSTB_2.5 3-GF-7.62
K1301, K1302, K1303, K1304: G6KU-2F-Y; G6K-2F
K1401, K1402, K1403, K1404, K1405, K1406, K1407: MS05-1A87-75D; MS05-1A87-75D_Socket
L501: 270n; R_0603
L502: 390n; R_0603
L503: 470n; R_0603
L701: ACT45B-101-2P-TL003; ACT45B
L801: CW252016-R33G; CW252016
L901: MPZ2012S221A; R_0805_Symbol1
L902: 749010012A; Wurth_749010012A
L1201, L1202: DRQ127-220; DRQ127
L1203, L1204: 1217AS-H-100M; DEM8045C
Q401: MMBF5486; SOT-23
Q402, Q413: MMBT200; SOT-23
Q403, Q408, Q414: SMBT2222; SOT-23
Q404, Q405, Q406, Q407: BCP56-16; SOT-223-3_TabPin2
Q409, Q410, Q411, Q412: BCP53; SOT-223-3_TabPin2
Q1201: Si7456DP; PowerPAK-SO-8
Q1202: IRFR5410; TO-252-2_Rectifier
Q1203: SI7850DP; PowerPAK-SO-8
Q1204, Q1205: FDMC5614P; PowerPAK-SO-8
R201, R508, R510, R602: 200; R_0603
R202, R302, R304, R305, R306, R307, R310, R311, R313, R315, R316, R317, R321, R323, R326, R327, R328, R331, R333, R334, R335, R336, R337, R338, R340, R341, R345, R346, R413, R603, R801, R805, R901, R902, R903, R910, R916, R1102, R1103, R1105, R1106, R1107, R1109, R1110, R1111, R1113, R1210, R1225, R1421, R1430, R1436, R1437: 10k; R_0603_Symbol1
R203, R204, R604, R605: 4k7; R_0603_Symbol6
R301, R308, R309, R318, R320, R330: 2k49; R_0603_Symbol5
R303, R322: 40k; R_0603
R312, R332, R406, R420: 30k; R_0603_Symbol7
R314, R324, R325, R329, R702, R703, R917, R1228, R1229, R1233, R1237, R1238, R1242: 0; R_0603_Symbol2
R319, R1301, R1302, R1303, R1304, R1305, R1306, R1307, R1308, R1309, R1310, R1311, R1312, R1313, R1314, R1315, R1316, R1317, R1318, R1402, R1403, R1404, R1405, R1408, R1409, R1415, R1416, R1417: 750; R_0603_Symbol8
R339, R401, R412, R804, R1319, R1320, R1321, R1322, R1427, R1432: 1k; R_0603_Symbol9
R342, R1438: 49k9; R_0603
R343: 12k4; R_0603
R344: 75k; R_0603
R402, R422: 300; R_0603
R403, R421, R1433: 3k9; R_0603
R404: 3k3; R_0603
R405, R908, R909, R911: 33; R_0603
R407: 1k8; R_0603
R408, R409, R410, R411, R416, R417, R418, R419: 10/2W; R_2512
R414: 470; R_0603
R415, R1434: 510; R_0603
R501: 33k2; R_0603
R502: 24k9; R_0603
R503, R1213, R1226, R1231, R1235, R1240, R1425, R1426, R1428, R1431, R1435: 100k; R_0603_Symbol3
R504, R505: 17k4; R_0603
R506: 511; R_0603
R507, R1429: 51; R_0603
R509: 6k81; R_0603
R511, R601, R1101, R1202, R1204, R1205, R1206, R1207, R1208, R1218, R1243: R; R_0603
R701: 120; R_1206
R802: 255; R_0603
R803, R1216, R1219: NC; R_0603
R806: 47; R_0603
R807: 100; R_0603
R808: 14k7; R_0603
R809: 51R1; R_0603
R904, R905, R906, R907: 50; R_0603_Symbol4
R912: 12K1; R_0603
R913: 1k5; R_0603
R914, R915: 75; R_0603
R918: 1Meg/1kV; R_1206
R919, R920: 270; R_0603
R1104, R1112: 2k49; R_0603
R1108: 10; R_0603
R1201: 154k; R_0603
R1203, R1215: 32k4; R_0603
R1209, R1224: 41k2; R_0603
R1211: 200k; R_0603
R1212: 120; R_0603
R1214: R; R_1206
R1217: R; R_0603_Symbol3
R1220, R1221: R; R_0603_Symbol2
R1230, R1239: 9k53; R_0603
R1232: 422k; R_0603
R1234: 80k6; R_0603
R1401: 10G/10%; R_0805
R1406: 1G/1%; R_1206
R1407: 100Meg/1%; R_1206
R1410: 10Meg/1%; R_1206
R1411: 1Meg/0.5%; R_1206
R1412: 250; R_1206
R1413: 100k/0.5%; R_1206
R1414: 180k/0.1%; R_0603
R1418: 10k/0.5%; R_1206
R1419: 18k/0.1%; R_0603
R1420: 1k/0.5%; R_1206
R1422: 2k/0.1%; R_0603
R1423: 100/0.1%/2W; R_1206
R1424: 10/1%/2W; R_2512
R1501, R1502, R1503, R1504: 100; R_0603_Symbol10
U201: STM32F746ZGTx; TQFP-144
U202, U602: 24LC08; MSOP-8_3x3mm_Pitch0.65mm
U301, U302, U309, U310, U313, U315, U506, U1103, U1104: LT1801; SOIC-8_3.9x4.9mm_Pitch1.27mm
U303, U311, U1417: AD746; SOIC-8_3.9x4.9mm_Pitch1.27mm
U304, U501: REF5025AD; SOIC-8_3.9x4.9mm_Pitch1.27mm
U305: LT1715; MSOP-10_3x3mm_Pitch0.5mm
U306: NC7SZ125; SOT-23-5
U307: DAC80004; TSSOP-14_4.4x5mm_Pitch0.65mm
U308, U1301, U1302, U1303, U1304, U1305, U1306, U1307, U1308, U1311, U1312, U1313, U1314, U1315, U1316, U1317, U1318, U1319, U1322, U1401, U1402, U1403, U1404, U1408, U1409, U1412, U1413, U1414: AQY221; AQY2
U312, U317, U318, U320, U509, U1109, U1325, U1326: SN74LVC1T45; SC70-6
U314, U316, U1102: ADG419BRM; SOIC-8_3.9x4.9mm_Pitch1.27mm
U319, U1107: OP07; SOIC-8_3.9x4.9mm_Pitch1.27mm
U401, U1411, U1415, U1416: AD744; SOIC-8_3.9x4.9mm_Pitch1.27mm
U502: LT1677; SOIC-8_3.9x4.9mm_Pitch1.27mm
U503: DAC8531; MSOP-8_3x3mm_Pitch0.65mm
U504: AD9834; SSOP-20_4.4x6.5mm_Pitch0.65mm
U505: AD5452; MSOP-8_3x3mm_Pitch0.65mm
U601: STM32F746ZETx; TQFP-144
U701: MCP2562-E_SN; SOIC-8_3.9x4.9mm_Pitch1.27mm
U801: 74AC125; SOIC-14_3.9x8.7mm_Pitch1.27mm
U802: NXE1S0305MC; NXE1
U803: 74LVC1G14; SOT-353_SC-70-5
U804: ACPL-214; SO4
U805, U806: HCPL0710; SOIC8NB
U901: USBLC6-4; SOT-23-6
U902, U903: LC03-3.3; SO8E
U904: LAN8742A; QFN-24-1EP_4x4mm_Pitch0.5mm
U1101: LTC6655-5; MSOP-8_3x3mm_Pitch0.65mm
U1106: ADG5204_TSSOP; TSSOP-14_4.4x5mm_Pitch0.65mm
U1108: LTC2512-24; DFN-24-1EP_4x7mm_Pitch0.5mm
U1201: NCP1117-ADJ_TO252; DPAK
U1202, U1206: LT3758; MSOP-10-1EP_3x3mm_Pitch0.5mm
U1203: LM337_TO252; DPAK
U1204: MAX5902; SOT23_6
U1205: TEN 40-2415N; TEN40
U1207, U1209: NCP1117-3.3_TO252; DPAK
U1208, U1210: LTC3864; MSOP-12-1EP_3x4mm_Pitch0.65mm
U1211: NCP1117-5.0_TO252; DPAK
U1309, U1320, U1323: TCA9534; TSSOP-16_4.4x5mm_Pitch0.65mm
U1310, U1321, U1324, U1406, U1410: ADG3308; SSOP-20_4.4x6.5mm_Pitch0.65mm
U1405: ULN2002; SO16E
U1407: TCA9555_TSSOP; TSSOP-24_4.4x7.8mm_Pitch0.65mm
U1501: STEF4S; DFN-10-1EP_3x3mm_Pitch0.5mm
U1601, U1602: OPA2344; SOIC-8_3.9x4.9mm_Pitch1.27mm
U1604: DG408DY; SOIC-16_3.9x9.9mm_Pitch1.27mm
U1605: OPA344; SOT-23-5
U1606: ADS1110; SOT-23-6
X201, X601: ABMM2-8.000MHZ; ABMM2
X501: XO53050UITA; XO53
X901: 7M-25.000MAAJ-T; 7M

Connections:
+2V5: C1122.1, U1108.3
+3V3: C306.1, C307.1, C308.1, C309.1, C310.1, C518.1, C519.1, C520.1, C521.1, C522.1, C1111.1, C1112.1, C1306.1, C1307.1, C1308.1, C1309.1, C1310.1, C1311.1, C1312.1, C1313.1, R324.1, U307.3, U312.1, U317.1, U318.1, U320.1, U503.1, U504.5, U505.6, U509.1, U1108.22, U1109.1, U1309.1, U1309.16, U1310.1, U1310.10, U1320.2, U1320.16, U1321.1, U1321.10, U1323.1, U1323.2, U1323.16, U1324.1, U1324.10, U1325.1, U1326.1, U1406.1, U1406.10, U1407.24, U1410.1, U1410.10, X501.4
+5V: C321.1, C322.1, C323.1, C324.1, C325.1, C326.1, C506.2, C523.1, C524.1, C525.1, C526.1, C1119.1, C1120.1, C1121.1, C1273.1, C1274.1, C1301.1, C1302.1, C1303.1, C1304.1, C1305.1, D1301.1, D1302.1, D1303.1, D1304.1, D1401.1, D1402.1, D1403.1, D1404.1, D1405.1, D1406.1, D1407.1, FB1205.1, K1301.1, K1302.1, K1303.1, K1304.1, K1401.2, K1402.2, K1403.2, K1404.2, K1405.2, K1406.2, K1407.2, U304.2, U305.5, U305.6, U306.5, U312.6, U314.5, U316.5, U317.6, U318.6, U320.6, U501.2, U504.4, U509.6, U701.3, U1102.5, U1109.6, U1301.1, U1302.1, U1303.1, U1304.1, U1305.1, U1306.1, U1307.1, U1308.1, U1310.20, U1311.1, U1312.1, U1313.1, U1314.1, U1315.1, U1316.1, U1317.1, U1318.1, U1319.1, U1321.20, U1322.1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
+5V_TRG: C801.1, C802.1, C803.1, C804.1, R801.1, R804.1, U801.14, U802.8, U803.5, U805.8, U806.1
+15V: C327.1, C328.1, C329.1, C330.1, C331.1, C332.1, C333.1, C334.1, C335.1, C336.1, C407.1, C408.1, C531.1, C532.1, C533.1, C534.1, C1113.1, C1114.1, C1115.1, C1116.1, C1117.1, C1118.1, C1215.1, C1216.1, C1416.1, C1417.1, C1418.1, C1419.1, C1420.1, C1421.1, C1422.1, C1423.1, D401.2, FB1201.1, Q401.1, Q403.3, Q404.2, Q405.2, Q406.2, Q407.2, R345.1, R402.1, R1101.1, U301.8, U302.8, U303.8, U309.8, U310.8, U311.8, U313.8, U314.4, U315.8, U316.4, U319.7, U401.7, U502.7, U506.8, U1102.4, U1103.8, U1104.8, U1106.12, U1107.7, U1411.7, U1415.7, U1416.7, U1417.8
-15V: C311.1, C312.1, C313.1, C314.1, C315.1, C316.1, C317.1, C318.1, C319.1, C320.1, C409.1, C410.2, C527.1, C528.1, C529.1, C530.1, C1105.1, C1106.1, C1107.1, C1108.1, C1109.1, C1110.1, C1235.1, C1236.1, D402.1, FB1202.1, Q409.2, Q410.2, Q411.2, Q412.2, Q413.3, R344.2, R346.2, R404.2, R422.2, U301.4, U302.4, U303.4, U309.4, U310.4, U311.4, U313.4, U314.7, U315.4, U316.7, U319.4, U401.4, U502.4, U506.4, U1102.7, U1103.4, U1104.4, U1106.3, U1107.4, U1411.4, U1415.4, U1416.4, U1417.4
/ADC/ADC_SCK: U1108.18, U1108.19
/ADC/ADC_SDO: U1108.17, U1108.20
/Address/CODE_3V3: C1501.1, C1502.1, U1501.8, U1501.9, U1501.10
/Address/MCU_CODE_0: D1501.1, D1502.1, R1501.2
/Address/MCU_CODE_1: D1503.1, D1504.1, R1502.2
/Address/MCU_CODE_2: D1505.1, D1506.1, R1503.2
/Address/MCU_CODE_3: D1507.1, D1508.1, R1504.2
/CAN/CAN_H: C706.1, D701.1, L701.4, R701.1
/CAN/CAN_L: C707.1, D701.2, L701.3, R701.2
/CAN/CAN_STBY: R703.1, U601.102
/Ethernet/ETH_NRST: R917.2, U601.127
/Ethernet/LED_GREEN: D901.2, U904.2
/Ethernet/LED_YELLOW: D902.2, U904.3
/Ethernet/RMII_CRS_DV: R911.2, U601.43
/Ethernet/RMII_MDC: U601.27, U904.13
/Ethernet/RMII_MDIO: R913.1, U601.36, U904.12
/Ethernet/RMII_REF_CLK: R916.1, U601.35, U904.14
/Ethernet/RMII_RXD0: R908.2, U601.44
/Ethernet/RMII_RXD1: R909.2, U601.45
/Ethernet/RMII_TXD0: U601.128, U904.17
/Ethernet/RMII_TXD1: U601.74, U904.18
/Ethernet/RMII_TX_EN: U601.126, U904.16
/Feed-Forward Current Booster/CurrentBoostOUT: R401.1, R408.2, R409.2, R410.2, R411.2, R416.1, R417.1, R418.1, R419.1
/Feedback/CURRENT_FEEDBACK: R1431.2, U1417.7
/Feedback/CurrentBoostOUT: C1402.2, C1404.2, C1406.2, C1410.1, R1401.2, R1406.2, R1407.2, R1410.2, R1426.1, U1401.4, U1402.4, U1403.4, U1404.4, U1408.4, U1409.4
/Feedback/GRD_RLY: D1407.2, K1407.3, U1405.10
/Feedback/GUARD_OUT: R1430.1, R1434.1
/Feedback/K1A: D1406.2, K1406.3, U1405.16
/Feedback/K1uA: D1403.2, K1403.3, U1405.13
/Feedback/K10nA: D1401.2, K1401.3, U1405.11
/Feedback/K10uA-10mA: D1404.2, K1404.3, U1405.14
/Feedback/K100mA: D1405.2, K1405.3, U1405.15
/Feedback/K100nA: D1402.2, K1402.3, U1405.12
/Feedback/STIMULUS: C1413.2, K1405.4, K1406.4, R1412.1, R1421.2, R1427.1
/Feedback/U1A: R1402.2, U1410.17
/Feedback/U1mA: R1405.2, U1410.14
/Feedback/U10mA: R1404.2, U1410.15
/Feedback/U10uA: R1409.2, U1410.12
/Feedback/U100mA: R1403.2, U1410.16
/Feedback/U100uA: R1408.2, U1410.13
/Feedback/VF_GAIN1: R1417.2, U1410.18
/Feedback/VF_GAIN10: R1416.2, U1410.19
/Feedback/VF_GAIN100: R1415.2, U1406.12
/Feedback/VOLTAGE_FEEDBACK: R1414.1, U1411.6, U1412.4
/MCU Main/CAN1_RX: U601.103, U701.4
/MCU Main/CAN1_TX: U601.104, U701.1
/MCU Main/MAIN-I2C1_SCL: R605.2, U601.140, U602.6
/MCU Main/MAIN-I2C1_SDA: R604.2, U601.139, U602.5
/MCU Main/MAIN-NC-TDI: J601.8, U601.110
/MCU Main/MAIN-NRST: C606.1, J601.10, R603.2
/MCU Main/MAIN-SWDCKL-TCK: J601.4, U601.109
/MCU Main/MAIN-SWDIO-TMS: J601.2, U601.105
/MCU Main/MAIN-SWO-TDO: J601.6, U601.133
/MCU Second/SECOND-I2C1_SCL: R204.2, U201.139, U202.6
/MCU Second/SECOND-I2C1_SDA: R203.2, U201.140, U202.5
/MCU Second/SECOND-NC-TDI: J201.8, U201.110
/MCU Second/SECOND-NRST: C206.1, J201.10, R202.2
/MCU Second/SECOND-SWDCKL-TCK: J201.4, U201.109
/MCU Second/SECOND-SWDIO-TMS: J201.2, U201.105
/MCU Second/SECOND-SWO-TDO: J201.6, U201.133
/MUX/A: K1302.3, U1301.3, U1302.3, U1303.3
/MUX/B: K1302.6, U1304.3, U1311.3, U1312.3
/MUX/C: K1303.3, U1305.3, U1313.3, U1314.3
/MUX/D: K1303.6, U1306.3, U1315.3, U1316.3
/MUX/E: K1304.3, U1307.3, U1317.3, U1318.3
/MUX/F: K1304.6, U1308.3, U1319.3, U1322.3
/MUX/GND_A: R1313.2, U1324.19
/MUX/GND_B: R1314.2, U1324.18
/MUX/GND_C: R1315.2, U1324.17
/MUX/GND_D: R1316.2, U1324.16
/MUX/GND_E: R1317.2, U1324.15
/MUX/GND_F: R1318.2, U1324.14
/MUX/GUARD_A: R1307.2, U1321.19
/MUX/GUARD_B: R1308.2, U1321.18
/MUX/GUARD_C: R1309.2, U1321.17
/MUX/GUARD_D: R1310.2, U1321.16
/MUX/GUARD_E: R1311.2, U1321.15
/MUX/GUARD_F: R1312.2, U1321.14
/MUX/GUARD_FRONT: J1301.2, K1301.7
/MUX/GUARD_REAR: K1301.5, U1302.4, U1312.4, U1314.4, U1316.4, U1318.4, U1319.4
/MUX/SECOND-I2C1_SCL: U1309.14, U1320.14, U1323.14
/MUX/SECOND-I2C1_SDA: U1309.15, U1320.15, U1323.15
/MUX/STIMULUS_FRONT: J1301.1, K1301.2
/MUX/STIMULUS_REAR: K1301.4, U1303.4, U1304.4, U1305.4, U1306.4, U1307.4, U1308.4
/MUX/STIM_A: R1301.2, U1310.19
/MUX/STIM_B: R1302.2, U1310.18
/MUX/STIM_C: R1303.2, U1310.17
/MUX/STIM_D: R1304.2, U1310.16
/MUX/STIM_E: R1305.2, U1310.15
/MUX/STIM_F: R1306.2, U1310.14
/Trigger/EXT_TRG: C808.1, D803.1, L801.1
/Trigger/TRG_IN: R805.1, U806.6
/Trigger/TRG_OUT_EN: U801.4, U801.10, U801.13, U803.4
/Trigger/TRG_OUT_SIGN: R803.1, U801.5, U801.9, U801.12, U805.6
/V/I Control/+IDAC: R305.1, R317.1, U302.5
/V/I Control/+VDAC: R334.1, U309.5
/V/I Control/-IDAC: R307.1, R328.1, U302.3
/V/I Control/-VDAC: R327.1, U309.3
/V/I Control/I_CLAMP_STATUS: D306.1, R314.2
/V/I Control/SIGN_SELECT: U317.3, U320.3
/V/I Control/VI_CLAMP: R304.1, R313.1, R323.1, R333.1, R335.1, R338.2, U313.6, U313.7, U316.8
/V/I Control/VREF+2V5: C302.1, C303.1, R308.1, R318.1, R330.1, U304.6, U307.7
CGND: C902.2, C912.1, R918.1
GND: C201.2, C202.2, C203.2, C204.2, C205.1, C206.2, C207.2, C208.2, C209.2, C210.2, C211.2, C212.2, C213.2, C214.2, C215.2, C216.2, C217.2, C218.2, C219.2, C220.2, C301.2, C302.2, C303.2, C306.2, C307.2, C308.2, C309.2, C310.2, C311.2, C312.2, C313.2, C314.2, C315.2, C316.2, C317.2, C318.2, C319.2, C320.2, C321.2, C322.2, C323.2, C324.2, C325.2, C326.2, C327.2, C328.2, C329.2, C330.2, C331.2, C332.2, C333.2, C334.2, C335.2, C336.2, C401.1, C403.1, C406.1, C407.2, C408.2, C409.2, C410.1, C502.2, C503.2, C504.2, C505.1, C507.2, C514.2, C515.2, C516.2, C517.2, C518.2, C519.2, C520.2, C521.2, C522.2, C523.2, C524.2, C525.2, C526.2, C527.2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
GNDD: C701.2, C702.2, C703.2, C704.2, C705.2, C706.2, C707.2, D701.3, R702.2, R912.1, U701.2
GNDPWR: C1237.2, C1238.2, C1239.1, D1204.2, D1205.1, U1204.4, U1205.2
GND_TRG: C801.2, C802.2, C803.2, C804.2, D801.2, D802.1, D803.2, R803.2, R809.2, U801.1, U801.7, U802.7, U803.3, U804.3, U805.5, U806.4
GUARD1: R1429.2, U1415.2, U1415.6
MCU1_3V3: C607.1, C608.1, C609.1, C610.1, C611.1, C612.1, C613.1, C614.1, C615.1, C616.1, C617.1, C618.1, C619.1, C620.1, C805.1, C806.1, C807.1, C1248.1, C1249.1, C1601.1, C1602.1, C1603.1, C1604.1, C1605.1, C1606.1, C1607.1, FB601.2, FB602.1, FB1203.1, J601.1, R603.1, R604.1, R605.1, U601.17, U601.30, U601.39, U601.52, U601.62, U601.72, U601.84, U601.95, U601.108, U601.121, U601.131, U601.144, U602.8, U802.3, U805.1, U806.8, U1501.1, U1501.2, U1501.3, U1601.8, U1602.8, U1604.13, U1605.5, U1606.5
MCU2_3V3: C207.1, C208.1, C209.1, C210.1, C211.1, C212.1, C213.1, C214.1, C215.1, C216.1, C217.1, C218.1, C219.1, C220.1, C1259.1, C1260.1, FB201.2, FB202.1, FB1204.1, J201.1, R202.1, R203.1, R204.1, U201.17, U201.30, U201.39, U201.52, U201.62, U201.72, U201.84, U201.95, U201.108, U201.121, U201.131, U201.144, U202.8
MCU_3V3: C701.1, C702.1, C703.1, L901.1, R901.1, R902.1, R903.1, R913.2, R916.2, U701.5, U904.9
unnamed: C201.1, FB201.1, U201.6
unnamed: C202.1, U201.71
unnamed: C203.1, U201.106
unnamed: C204.1, U201.23, X201.1
unnamed: C205.2, R201.2, X201.3
unnamed: C301.1, U304.5
unnamed: C304.1, R336.1, R340.2, U315.1
unnamed: C304.2, R336.2, R338.1, U315.2
unnamed: C305.1, D311.2, D312.1, R335.2, U313.2
unnamed: C305.2, D311.1, D312.2, R339.2, U313.1
unnamed: C401.2, Q402.2, R402.2
unnamed: C402.1, C404.1, Q402.1, R403.2, R406.1
unnamed: C402.2, C405.2, Q401.2, R404.1
unnamed: C403.2, R413.1, U401.3
unnamed: C404.2, C405.1, Q414.1, R420.2, R421.1
unnamed: C406.2, Q414.2, R422.1
unnamed: C501.1, R503.1, R504.2, U502.6
unnamed: C501.2, R501.1, R502.1, R503.2, U502.2
unnamed: C502.1, U501.5
unnamed: C503.1, C504.1, R502.2, U501.6, U503.2
unnamed: C505.2, U504.6
unnamed: C506.1, U504.3
unnamed: C507.1, U504.2
unnamed: C508.1, R505.1, R507.2, U506.7
unnamed: C508.2, R504.1, R505.2, R506.1, U506.6
unnamed: C509.1, R506.2, U505.8, U506.1
unnamed: C509.2, U505.1, U506.2
unnamed: C510.1, U505.7
unnamed: C510.2, R510.1, U504.20
unnamed: C511.1, C512.2, C515.1, L501.2, L502.1
unnamed: C511.2, C514.1, L501.1
unnamed: C512.1, C513.2, C516.1, L502.2, L503.1
unnamed: C513.1, C517.1, L503.2
unnamed: C601.1, FB601.1, U601.6
unnamed: C602.1, U601.71
unnamed: C603.1, U601.106
unnamed: C604.1, U601.23, X601.1
unnamed: C605.2, R602.2, X601.3
unnamed: C704.1, L701.2, U701.7
unnamed: C705.1, L701.1, U701.6
unnamed: C808.2, R809.1
unnamed: C901.2, C905.1, C906.1, C907.1, C908.1, C909.1, L901.2, L902.2, L902.7, R904.1, R905.1, R906.1, R907.1, U901.5, U904.1, U904.19
unnamed: C902.1, R914.2, R915.2
unnamed: C903.1, C904.1, U904.6
unnamed: C910.1, U904.4, X901.1
unnamed: C911.1, U904.5, X901.3
unnamed: C1101.1, R1101.2, U1101.1, U1101.2
unnamed: C1102.1, R1102.2, R1111.1, U1101.6, U1101.7, U1108.8, U1108.9, U1108.10
unnamed: C1103.1, R1106.1, R1109.2, U1104.1
unnamed: C1103.2, R1106.2, R1107.1, U1104.2
unnamed: C1104.1, R1108.1, U1108.5
unnamed: C1201.1, C1202.1, D1201.2, L1201.4
unnamed: C1201.2, C1202.2, L1201.2, Q1201.1
unnamed: C1203.1, C1204.1, C1205.1, C1206.1, C1221.2, C1223.1, C1224.1, C1225.1, C1226.1, C1243.1, C1244.1, C1245.1, C1250.1, C1261.1, C1262.1, C1263.1, C1264.1, L1201.1, L1202.1, R1201.1, R1211.1, R1216.1, R1226.1, R1235.1, U1202.10, U1205.4, U1206.10, U1208.11, U1210.11
unnamed: C1207.1, C1208.1, C1209.1, C1210.1, C1211.1, C1212.1, D1201.1, R1207.1, U1201.3
unnamed: C1213.1, C1214.1, FB1201.2, R1202.1, U1201.2
unnamed: C1217.1, U1202.3
unnamed: C1218.1, U1202.8
unnamed: C1219.1, R1210.2
unnamed: C1220.1, C1222.1, D1202.2, L1202.4
unnamed: C1220.2, C1222.2, L1202.2, Q1203.1
unnamed: C1221.1, C1237.1, C1238.1, D1203.1, Q1202.2, R1214.1, U1204.2, U1205.1
unnamed: C1227.2, C1228.2, C1229.1, C1230.1, C1231.1, C1232.1, L1202.3, U1203.2
unnamed: C1233.1, C1234.1, FB1202.2, R1212.1, U1203.3
unnamed: C1240.1, U1206.3
unnamed: C1241.1, U1206.8
unnamed: C1242.1, R1225.2
unnamed: C1243.2, U1208.9
unnamed: C1246.1, C1247.1, FB1203.2, U1207.2
unnamed: C1250.2, R1228.2, U1208.10
unnamed: C1251.1, U1208.4
unnamed: C1252.1, R1230.2
unnamed: C1253.1, C1255.1, C1256.1, L1203.2, R1231.1, R1232.1, U1207.3, U1209.3
unnamed: C1253.2, R1232.2, R1234.1, U1208.5
unnamed: C1254.1, R1230.1, U1208.6
unnamed: C1257.1, C1258.1, FB1204.2, U1209.2
unnamed: C1261.2, U1210.9
unnamed: C1264.2, R1237.2, U1210.10
unnamed: C1265.1, U1210.4
unnamed: C1266.1, R1239.2
unnamed: C1267.1, C1269.1, C1270.1, L1204.2, R1240.1, U1211.3
unnamed: C1267.2, R1243.1, U1210.5
unnamed: C1268.1, R1239.1, U1210.6
unnamed: C1271.1, C1272.1, FB1205.2, U1211.2
unnamed: C1401.1, C1402.1, K1401.1, R1406.1
unnamed: C1403.1, C1404.1, K1402.1, R1407.1
unnamed: C1405.1, C1406.1, K1403.1, R1410.1
unnamed: C1407.1, C1408.1, K1404.1, R1411.1, R1413.1, R1418.1, R1420.1
unnamed: C1408.2, R1411.2, U1409.3
unnamed: C1409.1, C1410.2, R1425.1, R1426.2, U1417.2
unnamed: C1409.2, R1425.2, R1435.1, U1417.1
unnamed: C1411.1, R1427.2, R1428.1
unnamed: C1411.2, R1428.2, R1433.2
unnamed: C1412.1, U1415.5
unnamed: C1412.2, U1415.8
unnamed: C1413.1, R1434.2
unnamed: C1414.1, R1436.2, R1437.1, U1417.3
unnamed: C1415.1, R1432.2, U1416.6
unnamed: C1415.2, R1438.2, U1416.2
unnamed: C1503.1, U1501.6
unnamed: D301.1, D302.2, U302.1
unnamed: D301.2, R304.2, U302.2
unnamed: D302.1, D305.2, U308.3
unnamed: D303.1, R313.2, U302.6
unnamed: D303.2, D305.1, U302.7
unnamed: D304.1, U305.7
unnamed: D304.2, U305.8
unnamed: D304.3, R315.1
unnamed: D306.2, R329.2
unnamed: D306.3, R319.1
unnamed: D307.1, D308.2, U309.1
unnamed: D307.2, R323.2, U309.2
unnamed: D308.1, D310.2, R339.1, U308.4, U313.5
unnamed: D309.1, R333.2, U309.6
unnamed: D309.2, D310.1, U309.7
unnamed: D401.1, R403.1
unnamed: D402.2, R421.2
unnamed: D801.1, D802.2, R804.2
unnamed: D802.3, R806.1, R807.2, U801.6, U801.8, U801.11
unnamed: D901.1, R919.1
unnamed: D902.1, R920.1
unnamed: D1203.2, R1218.1
unnamed: D1204.1, F1201.2, Q1202.3, R1213.1, U1204.1
unnamed: D1205.2, R1214.2, R1218.2
unnamed: D1206.1, L1203.1, Q1204.1
unnamed: D1207.1, L1204.1, Q1205.1
unnamed: D1301.2, K1301.8
unnamed: D1302.2, K1302.8
unnamed: D1303.2, K1303.8
unnamed: D1304.2, K1304.8
unnamed: K1401.4, K1402.4, K1403.4, K1404.4, R1401.1, R1412.2
unnamed: K1405.1, R1423.1
unnamed: K1406.1, R1424.1
unnamed: K1407.1, R1429.1
unnamed: K1407.4, R1430.2
unnamed: L801.2, R806.2
unnamed: L902.1, R904.2, U901.3, U904.21
unnamed: L902.3, R905.2, U901.4, U904.20
unnamed: L902.6, R906.2, U901.1, U904.23
unnamed: L902.8, R907.2, U901.6, U904.22
unnamed: L902.9, U903.4
unnamed: L902.10, R914.1
unnamed: L902.11, U903.1
unnamed: L902.14, U902.4
unnamed: L902.15, R915.1
unnamed: L902.16, U902.1
unnamed: Q401.3, R401.2, R412.1, R413.2
unnamed: Q402.3, R405.2, R407.1
unnamed: Q403.1, Q408.3, R405.1
unnamed: Q403.2, Q404.1, Q405.1, Q406.1, Q407.1, R414.1
unnamed: Q404.3, R408.1
unnamed: Q405.3, R409.1
unnamed: Q406.3, R410.1
unnamed: Q407.3, R411.1
unnamed: Q408.1, R407.2, R415.1
unnamed: Q408.2, Q413.1, Q414.3, R415.2
unnamed: Q409.1, Q410.1, Q411.1, Q412.1, Q413.2, R414.2
unnamed: Q409.3, R416.2
unnamed: Q410.3, R417.2
unnamed: Q411.3, R418.2
unnamed: Q412.3, R419.2
unnamed: Q1201.2, U1202.7
unnamed: Q1201.3, R1205.1, U1202.6
unnamed: Q1202.1, U1204.3
unnamed: Q1203.2, U1206.7
unnamed: Q1203.3, R1220.1, U1206.6
unnamed: Q1204.2, R1229.1
unnamed: Q1204.3, R1228.1
unnamed: Q1205.2, R1238.1
unnamed: Q1205.3, R1237.1
unnamed: R201.1, U201.24
unnamed: R301.1, R302.2, U301.2
unnamed: R301.2, U301.1, U305.3
unnamed: R303.1, R307.2, U303.1
unnamed: R303.2, R306.1, U303.2
unnamed: R305.2, R308.2, U301.3
unnamed: R306.2, U307.4
unnamed: R309.1, R310.2, U301.6
unnamed: R309.2, U301.7, U305.2, U305.4
unnamed: R311.1, R312.2, U303.6
unnamed: R312.1, R317.2, U303.7
unnamed: R314.1, U306.4
unnamed: R315.2, U306.2
unnamed: R316.2, R318.2, U301.5
unnamed: R319.2, U308.1
unnamed: R320.1, R321.2, U310.2
unnamed: R320.2, U305.1, U310.1
unnamed: R322.1, R327.2, U311.1
unnamed: R322.2, R326.1, U311.2
unnamed: R324.2, R325.2, U307.6
unnamed: R326.2, U307.10
unnamed: R328.2, R330.2, U310.3
unnamed: R329.1, U312.4
unnamed: R331.1, R332.2, U311.6
unnamed: R332.1, R334.2, U311.7
unnamed: R337.1, U315.7, U316.2
unnamed: R337.2, R340.1, U315.6
unnamed: R341.1, U313.3
unnamed: R341.2, U314.1
unnamed: R342.1, U314.8, U319.6
unnamed: R342.2, R343.1, R344.1, U319.3
unnamed: R343.2, U318.4
unnamed: R345.2, R346.1, U310.5
unnamed: R406.2, R420.1, U401.6
unnamed: R508.1, U504.19
unnamed: R509.2, U504.1
unnamed: R601.1, U601.138
unnamed: R602.1, U601.24
unnamed: R702.1, R703.2, U701.8
unnamed: R801.2, U803.2, U804.4
unnamed: R802.1, U804.2
unnamed: R807.1, R808.2, U801.2
unnamed: R808.1, U801.3, U806.2
unnamed: R901.2, R908.1, U904.8
unnamed: R902.2, R909.1, U904.7
unnamed: R903.2, R911.1, U904.11
unnamed: R910.1, U904.10
unnamed: R912.2, U904.24
unnamed: R917.1, U904.15
unnamed: R1102.1, U1106.4
unnamed: R1103.1, U1104.7
unnamed: R1103.2, R1109.1, U1104.6
unnamed: R1104.1, U1103.1, U1103.5
unnamed: R1104.2, R1105.1, U1103.2
unnamed: R1107.2, U1102.2
unnamed: R1108.2, U1103.6, U1103.7
unnamed: R1110.1, R1112.1, U1103.3
unnamed: R1111.2, R1113.1, U1107.3
unnamed: R1112.2, U1107.2, U1107.6
unnamed: R1201.2, R1203.1, U1202.9
unnamed: R1202.2, R1204.1
unnamed: R1204.2, R1206.1, U1201.1
unnamed: R1207.2, R1208.1, U1202.2
unnamed: R1209.1, U1202.4
unnamed: R1210.1, U1202.1
unnamed: R1211.2, R1215.1, U1206.9
unnamed: R1212.2, R1217.1, U1203.1
unnamed: R1213.2, U1204.6
unnamed: R1216.2, R1219.1, U1205.6
unnamed: R1217.2, R1221.1
unnamed: R1224.1, U1206.4
unnamed: R1225.1, U1206.1
unnamed: R1226.2, U1208.8
unnamed: R1229.2, U1208.12
unnamed: R1231.2, U1208.7
unnamed: R1233.1, U1208.2
unnamed: R1235.2, U1210.8
unnamed: R1238.2, U1210.12
unnamed: R1240.2, U1210.7
unnamed: R1242.1, U1210.2
unnamed: R1301.1, U1303.2
unnamed: R1302.1, U1304.2
unnamed: R1303.1, U1305.2
unnamed: R1304.1, U1306.2
unnamed: R1305.1, U1307.2
unnamed: R1306.1, U1308.2
unnamed: R1307.1, U1302.2
unnamed: R1308.1, U1312.2
unnamed: R1309.1, U1314.2
unnamed: R1310.1, U1316.2
unnamed: R1311.1, U1318.2
unnamed: R1312.1, U1319.2
unnamed: R1313.1, U1301.2
unnamed: R1314.1, U1311.2
unnamed: R1315.1, U1313.2
unnamed: R1316.1, U1315.2
unnamed: R1317.1, U1317.2
unnamed: R1318.1, U1322.2
unnamed: R1319.2, U1325.4
unnamed: R1320.2, R1321.2, R1322.2, U1326.4
unnamed: R1402.1, U1401.2
unnamed: R1403.1, U1402.2
unnamed: R1404.1, U1403.2
unnamed: R1405.1, U1404.2
unnamed: R1408.1, U1408.2
unnamed: R1409.1, U1409.2
unnamed: R1413.2, U1408.3
unnamed: R1414.2, R1419.1, U1414.4
unnamed: R1415.1, U1413.2
unnamed: R1416.1, U1414.2
unnamed: R1417.1, U1412.2
unnamed: R1418.2, U1404.3
unnamed: R1419.2, R1422.1, U1413.4
unnamed: R1420.2, U1403.3
unnamed: R1421.1, U1411.3
unnamed: R1423.2, U1402.3
unnamed: R1424.2, U1401.3
unnamed: R1431.1, R1435.2, U1417.6
unnamed: R1432.1, R1436.1, R1438.1, U1415.3
unnamed: R1433.1, U1416.3
unnamed: U303.5, U307.5
unnamed: U307.11, U311.5
unnamed: U310.6, U310.7
unnamed: U314.6, U320.4
unnamed: U316.6, U317.4
unnamed: U502.3, U503.3, U503.4
unnamed: U504.8, X501.3
unnamed: U1102.1, U1106.6
unnamed: U1102.6, U1109.4
unnamed: U1309.4, U1310.2
unnamed: U1309.5, U1310.3
unnamed: U1309.6, U1310.4
unnamed: U1309.7, U1310.5
unnamed: U1309.9, U1310.6
unnamed: U1309.10, U1310.7
unnamed: U1320.4, U1321.2
unnamed: U1320.5, U1321.3
unnamed: U1320.6, U1321.4
unnamed: U1320.7, U1321.5
unnamed: U1320.9, U1321.6
unnamed: U1320.10, U1321.7
unnamed: U1323.4, U1324.2
unnamed: U1323.5, U1324.3
unnamed: U1323.6, U1324.4
unnamed: U1323.7, U1324.5
unnamed: U1323.9, U1324.6
unnamed: U1323.10, U1324.7
unnamed: U1405.1, U1406.19
unnamed: U1405.2, U1406.18
unnamed: U1405.3, U1406.17
unnamed: U1405.4, U1406.16
unnamed: U1405.5, U1406.15
unnamed: U1405.6, U1406.14
unnamed: U1405.7, U1406.13
unnamed: U1406.2, U1407.4
unnamed: U1406.3, U1407.5
unnamed: U1406.4, U1407.6
unnamed: U1406.5, U1407.7
unnamed: U1406.6, U1407.8
unnamed: U1406.7, U1407.9
unnamed: U1406.8, U1407.10
unnamed: U1406.9, U1407.11
unnamed: U1407.13, U1410.2
unnamed: U1407.14, U1410.3
unnamed: U1407.15, U1410.4
unnamed: U1407.16, U1410.5
unnamed: U1407.17, U1410.6
unnamed: U1407.18, U1410.7
unnamed: U1407.19, U1410.8
unnamed: U1407.20, U1410.9
unnamed: U1411.2, U1412.3, U1413.3, U1414.3
unnamed: U1601.1, U1601.2, U1604.4
unnamed: U1601.6, U1601.7, U1604.5
unnamed: U1602.1, U1602.2, U1604.6
unnamed: U1602.6, U1602.7, U1604.7
unnamed: U1604.8, U1605.3
unnamed: U1605.1, U1605.4, U1606.1
VDDA: FB602.2, U601.32, U601.33
VDDF: FB202.2, U201.32, U201.33

## Code that names these connections

File SOFTWARE/MCU1/ETH1CSMU1_MCU1.ioc (part):

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Mcu.Name=STM32H743ZITx
Mcu.Package=LQFP144
Mcu.UserName=STM32H743ZITx
PA1.Mode=RMII
PA1.Signal=ETH_REF_CLK
PA10.GPIOParameters=GPIO_Label
PA10.GPIO_Label=CXN_REL5
PA10.Signal=GPIO_Output
PA11.GPIOParameters=GPIO_Label
PA11.GPIO_Label=ADC_HS_RVS2
PA11.Signal=GPIO_Input
PA12.GPIOParameters=GPIO_Label
PA12.GPIO_Label=ADC_HS_RVS1
PA12.Signal=GPIO_Input
PA13\ (JTMS/SWDIO).Mode=Serial_Wire
PA13\ (JTMS/SWDIO).Signal=DEBUG_JTMS-SWDIO
PA14\ (JTCK/SWCLK).Mode=Serial_Wire
PA14\ (JTCK/SWCLK).Signal=DEBUG_JTCK-SWCLK
PA15\ (JTDI).Mode=NSS_Signal_Hard_Output
PA15\ (JTDI).Signal=SPI3_NSS
PA2.Mode=RMII
PA2.Signal=ETH_MDIO
PA3.GPIOParameters=GPIO_Label
PA3.GPIO_Label=MCU_DEFAULT
PA3.Signal=GPIO_Input
PA4.Mode=NSS_Signal_Hard_Output
PA4.Signal=SPI1_NSS
PA5.Mode=Full_Duplex_Master
PA5.Signal=SPI1_SCK
PA6.Mode=Full_Duplex_Master
PA6.Signal=SPI1_MISO
PA7.Mode=RMII
PA7.Signal=ETH_CRS_DV
PA8.Mode=I2C
PA8.Signal=I2C3_SCL
PA9.GPIOParameters=GPIO_Label
PA9.GPIO_Label=CXN_REL4
PA9.Signal=GPIO_Output
PB11.GPIOParameters=GPIO_Label
PB11.GPIO_Label=MCU_nICLAMP
PB11.Signal=GPIO_Input
PB12.Mode=NSS_Signal_Hard_Output
PB12.Signal=SPI2_NSS
PB13.Mode=Full_Duplex_Master
PB13.Signal=SPI2_SCK
PB14.Mode=Full_Duplex_Master
PB14.Signal=SPI2_MISO
PB15.Mode=Full_Duplex_Master
PB15.Signal=SPI2_MOSI
PB5.Mode=SdramChipSelect2_2
PB5.Signal=FMC_SDCKE1
PB6.Mode=SdramChipSelect2_2
PB6.Signal=FMC_SDNE1
PC0.Signal=FMC_SDNWE
PC1.Mode=RMII
PC1.Signal=ETH_MDC
PC10.Mode=Full_Duplex_Master
PC10.Signal=SPI3_SCK
PC11.Mode=Full_Duplex_Master
PC11.Signal=SPI3_MISO
PC12.Mode=Full_Duplex_Master
PC12.Signal=SPI3_MOSI
PC13.GPIOParameters=PinState,GPIO_Label
PC13.GPIO_Label=LED_RED
PC13.PinState=GPIO_PIN_SET
PC13.Signal=GPIO_Output
PC14-OSC32_IN\ (OSC32_IN).GPIOParameters=GPIO_Label
PC14-OSC32_IN\ (OSC32_IN).GPIO_Label=LED_GREEN
PC14-OSC32_IN\ (OSC32_IN).Signal=GPIO_Output
PC15-OSC32_OUT\ (OSC32_OUT).GPIOParameters=PinState,GPIO_Label
PC15-OSC32_OUT\ (OSC32_OUT).GPIO_Label=LED_BLUE
PC15-OSC32_OUT\ (OSC32_OUT).PinState=GPIO_PIN_SET
PC15-OSC32_OUT\ (OSC32_OUT).Signal=GPIO_Output
PC4.Mode=RMII
PC4.Signal=ETH_RXD0
PC5.Mode=RMII
PC5.Signal=ETH_RXD1
PC6.GPIOParameters=GPIO_Label
PC6.GPIO_Label=CXN_REL1
PC6.Signal=GPIO_Output
PC7.GPIOParameters=GPIO_Label
PC7.GPIO_Label=CXN_REL2
PC7.Signal=GPIO_Output
PC8.GPIOParameters=GPIO_Label
PC8.GPIO_Label=CXN_REL3
PC8.Signal=GPIO_Output
PC9.Mode=I2C
PC9.Signal=I2C3_SDA
PD0.Signal=FMC_D2_DA2
PD1.Signal=FMC_D3_DA3
PD10.Signal=FMC_D15_DA15
PD11.GPIOParameters=GPIO_Label
PD11.GPIO_Label=EEPROM_WP
PD11.Signal=GPIO_Output
PD12.Mode=I2C
PD12.Signal=I2C4_SCL
PD13.Mode=I2C
PD13.Signal=I2C4_SDA
PD14.Signal=FMC_D0_DA0
PD15.Signal=FMC_D1_DA1
PD7.Mode=Full_Duplex_Master
PD7.Signal=SPI1_MOSI
PD8.Signal=FMC_D13_DA13
PD9.Signal=FMC_D14_DA14
PE0.Signal=FMC_NBL0
PE1.Signal=FMC_NBL1
PE10.Signal=FMC_D7_DA7
PE11.Signal=FMC_D8_DA8
PE12.Signal=FMC_D9_DA9
PE13.Signal=FMC_D10_DA10
PE14.Signal=FMC_D11_DA11
PE15.Signal=FMC_D12_DA12
PE2.Mode=Full_Duplex_Master
PE2.Signal=SPI4_SCK
PE4.Mode=NSS_Signal_Hard_Output
PE4.Signal=SPI4_NSS
PE5.Mode=Full_Duplex_Master
PE5.Signal=SPI4_MISO
PE6.Mode=Full_Duplex_Master
PE6.Signal=SPI4_MOSI
PE7.Signal=FMC_D4_DA4
PE8.Signal=FMC_D5_DA5
PE9.Signal=FMC_D6_DA6
PF0.Signal=FMC_A0
PF1.Signal=FMC_A1
PF11.Signal=FMC_SDNRAS
PF12.Signal=FMC_A6
PF13.Signal=FMC_A7
PF14.Signal=FMC_A8
PF15.Signal=FMC_A9
PF2.Signal=FMC_A2
PF3.Signal=FMC_A3
PF4.Signal=FMC_A4
PF5.Signal=FMC_A5
PF6.Mode=NSS_Signal_Hard_Output
PF6.Signal=SPI5_NSS
PF7.Mode=Full_Duplex_Master
PF7.Signal=SPI5_SCK
PF8.Mode=Full_Duplex_Master
PF8.Signal=SPI5_MISO
PF9.Mode=Full_Duplex_Master
PF9.Signal=SPI5_MOSI
PG0.Signal=FMC_A10
PG1.Signal=FMC_A11
PG11.Mode=RMII
PG11.Signal=ETH_TX_EN
PG13.Mode=RMII
PG13.Signal=ETH_TXD0
PG14.Mode=RMII
PG14.Signal=ETH_TXD1
PG15.Signal=FMC_SDNCAS
PG2.Signal=FMC_A12
PG3.GPIOParameters=GPIO_Label
PG3.GPIO_Label=TRIG_IN
PG3.Signal=GPIO_Input
PG4.Signal=FMC_A14_BA0
PG5.Signal=FMC_A15_BA1
PG6.GPIOParameters=GPIO_Label
PG6.GPIO_Label=TRIG_OUT
PG6.Signal=GPIO_Output
PG7.GPIOParameters=GPIO_Label
PG7.GPIO_Label=TRIG_EN
PG7.Signal=GPIO_Output
PG8.Signal=FMC_SDCLK
PH0-OSC_IN\ (PH0).Mode=HSE-External-Oscillator
PH0-OSC_IN\ (PH0).Signal=RCC_OSC_IN
PH1-OSC_OUT\ (PH1).Mode=HSE-External-Oscillator
PH1-OSC_OUT\ (PH1).Signal=RCC_OSC_OUT
RCC.HSE_VALUE=16000000
RCC.SYSCLKFreq_VALUE=480000000
RCC.SYSCLKSource=RCC_SYSCLKSOURCE_PLLCLK
board=custom

## Commit log

2018-11-06 Added schematic from different project
2018-11-08 Added ADC
2018-11-25 Power schematic
2018-11-26 Footprints
2018-11-29 Footprint selection
2018-12-03 Redesigned feedback circuit.
2018-12-04 Added MUX schematic
2018-12-09 Schematic development
2018-12-10 Changed BUS mux schematic
2018-12-16 check in
2018-12-31 Added test circuits, bug fix.
2019-01-02 Bug fix
2019-10-05 Layout redesign
2019-11-11 Base board schematic.
2019-11-11 Schematic developement, new footprints.
2019-11-14 Schematic design.
2020-04-04 Power supply design
2020-04-04 Footprint assigment
2020-04-07 Footprint assignment
2021-03-14 Schematic redesign, based on http://www.djerickson.com/diy_smu/index.html
2021-03-17 Schematic design
2021-03-22 PCB layout
2021-03-24 Design
2021-03-28 PCB and schematic design.
2021-03-29 PCB and schematic
2021-04-07 Schematic and PCB changes
2021-07-18 PCB modifications
2021-08-07 Schematic and PCB update.
2021-08-12 PCB changes
2021-10-05 Modifications in BASE PCB
2021-10-07 PCB cleanup
2021-10-08 PCB bug fix
2021-10-09 MODULE PCB changes
2021-11-07 Created active BOM list with Kicad plugin. Created first code for MCU1 and MCU2.
2022-05-17 Changed in Lib file
2022-07-31 Fixed 3d model paths
