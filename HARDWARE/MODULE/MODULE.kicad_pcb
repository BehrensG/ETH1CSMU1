# Repository BehrensG/ETH1CSMU1 (continued)

## KiCad design HARDWARE/BASE/BASE.kicad_pcb (continued)

Parts:
C901, C902, C903, C904, C907: 1000p; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C905, C911, C916: 10u; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
C906, C912, C914, C915, C941, C943: 1u; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C908, C909: 330p; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C910, C917, C918, C919, C920, C921, C922, C923, C924, C925, C926, C927, C928, C929, C930, C931, C932, C933, C934, C935, C936, C937, C938, C939: 100n; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C913: 4u7/25V; C_1206_3216Metric_Pad1.33x1.80mm_HandSolder
C940, C942: 22u; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R901: 2k/.1%; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R902: 2k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R903, R904, R905, R908, R909, R910, R912, R915, R919, R921, R924, R926: 10k/.1%; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R906: 20k5/.1%; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R907, R913, R914, R920: 21k5/.1%; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R911, R916, R917, R922, R923: 10k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R918, R925: 0; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R927, R928, R929: 0R22; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
TP901: TPDAC; TestPoint_Pad_2.0x2.0mm
U901: CPC1018N; SOP-4_3.8x4.1mm_P2.54mm
U902, U905, U907: DG419LDY; SOIC-8_3.9x4.9mm_P1.27mm
U903: TLC2272; SOIC-8_3.9x4.9mm_P1.27mm
U904: OPA2140; SOIC-8_3.9x4.9mm_P1.27mm
U906: AD7190RUZ; TSSOP-24_4.4x7.8mm_P0.65mm
U908: AD5686RARUZ; TSSOP-16_4.4x5mm_P0.65mm
U910: TL072; SOIC-8_3.9x4.9mm_P1.27mm
U912, U914: ADS8681PWR; TSSOP-16_4.4x5mm_P0.65mm
U915: ADR431ARZ; SOIC-8_3.9x4.9mm_P1.27mm
U916: REF5040ID; SOIC-8_3.9x4.9mm_P1.27mm

Connections:
+2V5: C912.1, R926.2, U906.10 (AINCOM), U906.15 (REFIN1+), U908.1 (VREF), U915.6 (VOUT)
+4V: R927.1, U912.4 (REFIO), U914.4 (REFIO), U916.6 (Vout)
+15V: C923.1, C924.1, C925.1, C926.1, C927.1, C928.1, U902.4 (V+), U903.8 (V+), U904.8 (V+), U905.4 (V+), U907.4 (V+), U910.8 (V+); also elsewhere on the board
-2V5: C913.1, R903.2, R905.2, R909.2, R912.2, R919.2, R924.1, U904.7
-15V: C917.1, C918.1, C919.1, C920.1, C921.1, C922.1, U902.7 (V-), U903.4 (V-), U904.4 (V-), U905.7 (V-), U907.7 (V-), U910.4 (V-); also elsewhere on the board
/Analog/CL+: C904.1, R913.1, U910.7; also elsewhere on the board
/Analog/CL-: C907.1, R920.1, U910.1; also elsewhere on the board
/Analog/FDACN: U905.1; also elsewhere on the board
/Analog/IM: U907.1; also elsewhere on the board
/Analog/VM: U902.1; also elsewhere on the board
/Control/ADC_HP_MISO: U906.23 (DOUT); also elsewhere on the board
/Control/ADC_HP_MOSI: U906.24 (DIN); also elsewhere on the board
/Control/ADC_HP_SCLK: U906.3 (SCLK); also elsewhere on the board
/Control/ADC_HP_~CS: U906.4 (~CS); also elsewhere on the board
/Control/ADC_HS_MISO: R923.2, U914.13 (SDO-0); also elsewhere on the board
/Control/ADC_HS_MOSI: U912.10 (SDI); also elsewhere on the board
/Control/ADC_HS_RVS1: U912.15 (RVS); also elsewhere on the board
/Control/ADC_HS_RVS2: U914.15 (RVS); also elsewhere on the board
/Control/ADC_HS_SCLK: U912.12 (SCLK), U914.12 (SCLK); also elsewhere on the board
/Control/ADC_HS_~CS: U912.11 (CONVST/~CS), U914.11 (CONVST/~CS); also elsewhere on the board
/Control/CAP1: R928.1, U912.6 (REFCAP)
/Control/CAP2: R929.1, U914.6 (REFCAP)
/Control/DAC_MISO: U908.8 (SDO); also elsewhere on the board
/Control/DAC_MOSI: U908.14 (SDIN); also elsewhere on the board
/Control/DAC_SCLK: U908.12 (SCLK); also elsewhere on the board
/Control/DAC_~CS: U908.13 (~SYNC); also elsewhere on the board
/Control/FDACLO: R902.1; also elsewhere on the board
/Control/FGEN: U905.8; also elsewhere on the board
unnamed: C901.1, R904.1, U903.1, U906.11 (AIN1)
unnamed: C901.2, R903.1, R904.2, R907.1, U903.2 (-)
unnamed: C902.1, R906.1, U901.3, U904.1, U905.2
unnamed: C902.2, R901.2, R905.1, R906.2, R908.1, U904.2 (-)
unnamed: C903.1, R910.1, U903.7, U906.12 (AIN2)
unnamed: C903.2, R909.1, R910.2, R914.1, U903.6 (-)
unnamed: C904.2, R912.1, R913.2, R915.1, U910.6 (-)
unnamed: C906.1, R911.2, U908.15 (~RESET)
unnamed: C907.2, R919.1, R920.2, R921.1, U910.2 (-)
unnamed: C908.1, R918.2, U912.7 (AIN_P)
unnamed: C909.1, R925.1, U914.7 (AIN_P)
unnamed: C915.1, U916.5 (Trim/NR)
unnamed: C916.1, R927.2
unnamed: C940.1, C941.1, R928.2
unnamed: C942.1, C943.1, R929.2
unnamed: R901.1, U901.4
unnamed: R902.2, U901.1
unnamed: R907.2, U902.2
unnamed: R908.2, U908.3 (VOUTA)
unnamed: R914.2, U907.2
unnamed: R915.2, U908.2 (VOUTB)
unnamed: R916.2, U912.9 (~RST)
unnamed: R917.2, U912.13 (SDO-0), U914.10 (SDI)
unnamed: R918.1, U902.8
unnamed: R921.2, U908.6 (VOUTC)
unnamed: R922.2, U914.9 (~RST)
unnamed: R924.2, R926.1, U904.6 (-)
unnamed: R925.2, U907.8
unnamed: TP901.1, U908.7 (VOUTD)

Schematic: Analog.sch

Parts:
C1001: 150p/500V; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C1002: 100p; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C1003: 22p/500V; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C1004, C1008, C1010: 270p; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C1005, C1009: 270p/500V; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C1006, C1011, C1012: 15p; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C1007: 1000p; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C1013: 150p; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C1014: 22p/100V; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C1015: 22p; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C1016, C1017, C1018, C1019, C1020, C1021, C1022, C1023, C1024, C1025, C1026, C1027, C1028, C1029, C1030, C1031, C1032, C1033, C1034, C1035: 100n; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C1036, C1037: 10p; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
D1001, D1003: 1N4148W; D_SOD-123
D1002, D1004, D1005, D1006, D1007, D1008: BAV99; SOT-23
J1001: Conn_02x02; PinHeader_2x02_P2.54mm_Vertical
J1002: Conn_02x06; PinHeader_2x06_P2.54mm_Vertical
K1001, K1002: TQ2SA-5V; SA
Q1001, Q1002: MMBT3904; SOT-23
R1001: 1k/500V; R_1206_3216Metric_Pad1.30x1.75mm_HandSolder
R1002: 5Meg/25ppm/.1%; R_1206_3216Metric_Pad1.30x1.75mm_HandSolder
R1003: 200k/500V; R_1206_3216Metric_Pad1.30x1.75mm_HandSolder
R1004, R1012, R1022: 20k/.1%; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R1005, R1006, R1008, R1009, R1010, R1013, R1014, R1018, R1019, R1021, R1024, R1025, R1028, R1030, R1032, R1037, R1040, R1047: 10k/.1%; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R1007: 560k/.1%; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R1011: 49k9/.1%; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R1015: 4k99; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R1016, R1017, R1031, R1036: 4k99/.1%; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R1020: 15k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R1023: 499/.25W/.1%; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R1026: 22k1/.1%; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R1027: 300k/.1%; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R1029, R1034: 100/1W/.5%; R_2512_6332Metric_Pad1.40x3.35mm_HandSolder
R1033, R1043, R1044: 2k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R1035: 2k; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R1038, R1039: 2/1W/.5%; R_2512_6332Metric_Pad1.40x3.35mm_HandSolder
R1041, R1042, R1045, R1046: 100k/.1%; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R1048: 1k/.1%; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R1049, R1050: 10k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
TP1001: TP+OUT; TestPoint_Pad_2.0x2.0mm
TP1002: TP+GUA; TestPoint_Pad_2.0x2.0mm
TP1003: TP-OUT; TestPoint_Pad_2.0x2.0mm
TP1004: TP-SEN; TestPoint_Pad_2.0x2.0mm
TP1005: TPVM; TestPoint_Pad_2.0x2.0mm
TP1006: TP+SEN; TestPoint_Pad_2.0x2.0mm
TP1007: TPIM; TestPoint_Pad_2.0x2.0mm
U1001, U1003, U1006, U1008, U1014: OPA2140; SOIC-8_3.9x4.9mm_P1.27mm
U1002, U1005, U1011: DG444DY+; SOIC-16_3.9x9.9mm_P1.27mm
U1004, U1012: OPA140; SOIC-8_3.9x4.9mm_P1.27mm
U1007: LM393; SOIC-8_3.9x4.9mm_P1.27mm
U1009: TLP170D; SO-4_4.4x3.9mm_P2.54mm
U1010, U1013: AQY221R2SZ; AQY212GS
U1015: TL071; SOIC-8_3.9x4.9mm_P1.27mm

Connections:
+15V: C1027.1, C1028.1, C1029.1, C1030.1, C1031.1, C1032.1, C1033.1, C1034.1, C1035.1, D1005.2 (A), J1002.9, J1002.10, U1001.8 (V+), U1002.13 (V+), U1003.8 (V+), U1004.7 (V+), U1005.13 (V+), U1006.8 (V+), U1007.8 (V+), U1008.8 (V+), U1011.13 (V+), U1014.8 (V+), U1015.7 (V+); also elsewhere on the board
+15VH: C1017.1, D1006.2 (A), D1007.2 (A), J1001.4, U1012.7 (V+)
-15V: C1018.1, C1019.1, C1020.1, C1021.1, C1022.1, C1023.1, C1024.1, C1025.1, C1026.1, D1005.1 (K), J1002.5, J1002.6, U1001.4 (V-), U1002.4 (V-), U1003.4 (V-), U1004.4 (V-), U1005.4 (V-), U1006.4 (V-), U1007.4 (V-), U1008.4 (V-), U1011.4 (V-), U1014.4 (V-), U1015.4 (V-); also elsewhere on the board
-15VH: C1016.1, D1006.1 (K), D1007.1 (K), J1001.2, U1012.4 (V-)
/Analog/10-100mA: J1002.1, J1002.2; also elsewhere on the board
/Analog/10mA: R1023.2, U1002.2, U1005.7
/Analog/100mA: R1029.2, R1034.2, U1005.2, U1010.4
/Analog/+GUA: K1001.7, TP1002.1; also elsewhere on the board
/Analog/+GUARD: K1001.8, R1044.1
/Analog/+OUT: K1001.4, TP1001.1; also elsewhere on the board
/Analog/+SEN: K1002.7, TP1006.1; also elsewhere on the board
/Analog/-SEN: K1002.4, TP1004.1; also elsewhere on the board
/Analog/AMPIN: J1002.3, J1002.4, U1001.6 (-), U1001.7
/Analog/CL+: R1008.2; also elsewhere on the board
/Analog/CL-: R1018.2; also elsewhere on the board
/Analog/CLM: R1010.2, R1021.2, U1011.6, U1011.11
/Analog/FDACN: R1028.2; also elsewhere on the board
/Analog/FM: R1032.2, U1008.6 (-), U1008.7
/Analog/IM: R1045.2, TP1007.1, U1011.10, U1011.15, U1014.1; also elsewhere on the board
/Analog/INT_GUARD: D1008.1 (K), D1008.2 (A), R1044.2, U1015.2 (-), U1015.6
/Analog/REL1: D1001.2 (A), K1001.10, Q1002.3 (C)
/Analog/REL2: D1003.2 (A), K1002.10, Q1001.3 (C)
/Analog/REL2_CTR: R1049.2; also elsewhere on the board
/Analog/VM: R1024.2, TP1005.1, U1006.1, U1011.2, U1011.7; also elsewhere on the board
/Analog/~10mA: U1002.1, U1005.8; also elsewhere on the board
/Analog/~10uA: U1002.9; also elsewhere on the board
/Analog/~100mA: U1005.1, U1010.2; also elsewhere on the board
/Analog/~ICLAMP: R1015.2, R1020.1; also elsewhere on the board
/Analog/~IMODE: U1011.8, U1011.16; also elsewhere on the board
/Analog/~VRANGE: U1009.2; also elsewhere on the board
unnamed: C1001.1, C1003.1, R1003.1, R1005.1, U1001.5 (+)
unnamed: C1001.2, R1001.1
unnamed: C1002.1, C1004.1, C1005.1, C1008.1, C1010.1, C1015.1, K1001.3, K1002.9, R1002.1, R1007.1, R1011.1, R1017.1, R1023.1, R1029.1, R1034.1, R1038.1, R1039.1, R1040.1
unnamed: C1002.2, J1002.11, J1002.12, R1002.2, U1002.3, U1002.6, U1002.11, U1002.14, U1005.10, U1010.3, U1013.3
unnamed: C1004.2, R1007.2, U1002.10
unnamed: C1005.2, C1009.1
unnamed: C1006.1, D1002.2 (A), R1004.2, U1003.2 (-)
unnamed: C1006.2, D1002.3 (K), U1003.1, U1007.3 (+)
unnamed: C1007.1, R1005.2, U1001.1
unnamed: C1007.2, R1009.1
unnamed: C1008.2, R1011.2, U1002.7
unnamed: C1010.2, R1017.2, U1002.15
unnamed: C1011.1, D1004.1 (K), R1012.2, U1003.6 (-)
unnamed: C1011.2, D1004.3 (K), U1003.7, U1007.6 (_)
unnamed: C1012.1, R1022.2, U1008.2 (-)
unnamed: C1012.2, R1031.2, U1008.1
unnamed: C1013.1, R1030.1, U1012.2 (-)
unnamed: C1013.2, R1036.1, U1012.6
unnamed: C1014.1, K1002.3, R1037.1
unnamed: C1014.2, D1007.3 (K), R1037.2, U1012.3 (+)
unnamed: C1015.2, D1008.3 (K), R1040.2, R1047.1
unnamed: C1036.2, Q1001.1 (B), R1049.1
unnamed: C1037.2, Q1002.1 (B), R1050.1
unnamed: D1002.1 (K), D1004.2 (A), R1004.1, R1006.2, R1012.1, R1022.1, R1031.1
unnamed: D1005.3 (K), R1016.2, U1004.3 (+)
unnamed: D1006.3 (K), R1027.1, R1030.2, R1036.2, U1009.3
unnamed: K1002.8, R1016.1
unnamed: R1006.1, R1009.2, U1001.2 (-)
unnamed: R1008.1, R1010.1, U1003.3 (+)
unnamed: R1013.1, R1014.2, U1006.3 (+)
unnamed: R1014.1, R1019.2, U1004.2 (-), U1004.6
unnamed: R1018.1, R1021.1, U1003.5 (+)
unnamed: R1019.1, R1026.2, R1027.2, U1006.5 (+)
unnamed: R1020.2, U1007.1, U1007.7
unnamed: R1024.1, R1025.2, U1006.2 (-)
unnamed: R1025.1, U1006.6 (-), U1006.7
unnamed: R1026.1, U1009.4
unnamed: R1028.1, R1032.1, U1008.3 (+)
unnamed: R1033.1, U1009.1
unnamed: R1035.2, U1010.1
unnamed: R1038.2, R1039.2, U1005.15, U1013.4
unnamed: R1041.1, R1042.2, U1014.3 (+)
unnamed: R1042.1, U1005.3, U1005.6, U1005.11, U1005.14
unnamed: R1043.2, U1013.1
unnamed: R1045.1, R1046.2, U1014.2 (-)
unnamed: R1046.1, R1048.2, U1014.6 (-), U1014.7
unnamed: R1047.2, U1014.5 (+)
unnamed: R1048.1, U1015.3 (+)
unnamed: U1008.5 (+), U1011.3, U1011.14
OCOM: C1003.2, C1009.2, C1016.2, C1017.2, J1001.1, J1001.3, K1002.2, R1001.2, R1003.2, TP1003.1; also elsewhere on the board

Schematic: FGEN.sch, Function generator

Parts:
C1101: 1p5; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C1102, C1119: 10n; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C1103: 4p7; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C1104: 18p; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C1105: 12p; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C1106: 10u; C_1206_3216Metric_Pad1.33x1.80mm_HandSolder
C1107, C1110, C1115, C1116, C1118, C1120, C1127, C1128, C1129, C1130, C1131, C1133, C1134, C1135, C1136, C1137, C1138, C1139, C1140, C1141, C1142, C1143, C1144, C1145, C1146, C1147, C1148, C1149, C1151: 100n; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C1108, C1132: 10u; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C1109, C1150, C1152: 1u; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C1111, C1114: 22p; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C1112, C1113: 56p; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C1117, C1121: 5p; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C1122: 220n; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C1123: 1n; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C1124, C1125: 8p; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C1126: 2u2; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
D1101, D1102: SD103ATW; SOT-363_SC-70-6
FB1101: 742792031; L_0805_2012Metric_Pad1.15x1.40mm_HandSolder
J1101: 20021111-00010T4LF; PinHeader_2x05_P1.27mm_Vertical
L1101, L1102, L1103: 4u7; L_0603_1608Metric_Pad1.05x0.95mm_HandSolder
R1101, R1102, R1118, R1119, R1126, R1127: 10k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R1103, R1106, R1114, R1120, R1122: 0; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R1104, R1121: 1k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R1105: 4k22; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R1107, R1117: 3k9; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R1108, R1109: 300; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R1110, R1111: 1k96; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R1112, R1113, R1115: 1k/.1%; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R1116: 9k/.1%; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R1123: 24k9; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R1124: 100k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R1125: 33k2; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R1128, R1129: 4k7; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
U1101, U1115: DG419LDY; SOIC-8_3.9x4.9mm_P1.27mm
U1102, U1103: LM318; SOIC-8_3.9x4.9mm_P1.27mm
U1104: AD5453YRMZ; MSOP-8_3x3mm_P0.65mm
U1105: LT1468; SSOP-8_3.9x5.05mm_P1.27mm
U1106: REF192; SSOP-8_3.9x5.05mm_P1.27mm
U1107: AD9835; TSSOP-16_4.4x5mm_P0.65mm
U1108, U1114: TL072; SOIC-8_3.9x4.9mm_P1.27mm
U1109: ECS-3225SMV-500-GP-TR; ECS
U1110: 74AHCT1G08; SOT-353_SC-70-5
U1111: AD5689BRUZ; TSSOP-16_4.4x5mm_P0.65mm
U1112: STM32F413RGT6Tx; LQFP-64_10x10mm_P0.5mm
U1113: 24LC08B-E/MS; MSOP-8_3x3mm_P0.65mm
Y1101: NX3225GD-8MHZ-STD-CRA-3; NX3225GD

Connections:
+15V: C1138.1, C1139.1, C1140.1, C1141.1, C1142.1, U1101.4 (V+), U1102.7 (V+), U1103.7 (V+), U1105.7 (V+), U1108.8 (V+), U1114.8 (V+), U1115.4 (V+); also elsewhere on the board
-15V: C1133.1, C1134.1, C1135.1, C1136.1, C1137.1, U1101.7 (V-), U1102.4 (V-), U1103.4 (V-), U1105.4 (V-), U1108.4 (V-), U1114.4 (V-), U1115.7 (V-); also elsewhere on the board
/Control/FGEN: U1101.8; also elsewhere on the board
/Function generator/+2V5REF: C1109.1, C1110.1, R1105.2, R1123.2, U1106.6 (Vout), U1111.1 (VREF)
/Function generator/ANALOG_SWITCH: U1101.6, U1112.29 (PB10,TIM2_CH3,I2C2_SCL,SPI2_SCK,I2S2_CK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)
/Function generator/DDS_DAC_RSTSEL: R1122.2, U1112.41 (PA8,MCO_1,TIM1_CH1,I2C3_SCL,DFSDM1_CKOU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)
/Function generator/DDS_DAC_SCLK: U1111.12 (SCLK), U1112.26 (PB0,TIM1_CH2N,TIM3_CH3,TIM8_CH2N,SPI5_S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)
/Function generator/DDS_DAC_SDIN: U1111.14 (SDIN), U1112.43 (PA10,TIM1_CH3,DFSDM2_DATIN3,SPI2_MOSI,I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)
/Function generator/DDS_DAC_SDO: U1111.8 (SDO), U1112.45 (PA12,TIM1_ETR,DFSDM2_DATIN5,SPI2_MISO,S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)
/Function generator/DDS_DAC_~LDAC: U1111.9 (~LDAC), U1112.28 (PB2,LPTIM1_OUT,DFSDM1_CKIN0,QUADSPI_CLK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)
/Function generator/DDS_DAC_~RESET: R1119.2, U1111.15 (~RESET), U1112.42 (PA9,TIM1_CH2,DFSDM2_CKIN3,I2C3_SMBA,SPI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)
/Function generator/DDS_DAC_~SYNC: R1118.2, U1111.13 (~SYNC), U1112.27 (PB1,TIM1_CH3N,TIM3_CH4,TIM8_CH3N,SPI5_N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)
/Function generator/DDS_FGEN_FSELECT: U1107.10 (FSELECT), U1112.17 (PA3,TIM2_CH4,_TIM5_CH4,TIM9_CH2,I2S2_MC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)
/Function generator/DDS_FGEN_PSEL0: U1107.12 (PSEL0), U1112.24 (PC4,DFSDM2_CKIN2,I2S1_MCK,_QUADSPI_BK2_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)
/Function generator/DDS_FGEN_PSEL1: U1107.11 (PSEL1), U1112.25 (PC5,DFSDM2_DATIN2,I2CFMP1_SMBA,USART3_R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)
/Function generator/DDS_FGEN_SCLK: U1107.7 (SCLK), U1112.21 (PA5,TIM2_CH1,TIM2_ETR,TIM8_CH1N,SPI1_SC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)
/Function generator/DDS_FGEN_SDATA: U1107.8 (SDATA), U1112.23 (PA7,TIM1_CH1N,TIM3_CH2,TIM8_CH1N,SPI1MO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)
/Function generator/DDS_FGEN_~FSYNC: R1101.2, U1107.9 (FSYNC), U1112.20 (PA4,SPI1_NSS,I2S1_WS,SPI3_NSS,I2S3_WS,U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)
/Function generator/DDS_MDAC_DIN: U1104.4 (SDIN), U1112.36 (PB15,RTC_REFIN,TIM1_CH3N,TIM8_CH3N,I2CF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)
/Function generator/DDS_MDAC_SCLK: U1104.3 (SCK), U1112.34 (PB13,TIM1_CH1N,I2CFMP1_SMBA,SPI2_SCK,I2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)
/Function generator/DDS_MDAC_~SYNC: U1104.5 (~SYNC), U1112.33 (PB12,TIM1_BKIN,I2C2_SMBA,SPI2_NSS,I2S2_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)
/Function generator/MCU_MISO: U1112.52 (PC11,DFSDM2_DATIN5,I2S3ext_SD,SPI3_MISO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); also elsewhere on the board
/Function generator/MCU_MOSI: U1112.53 (PC12,SPI3_MOSI,I2S3_SD,USART3_CK,UART5_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); also elsewhere on the board
/Function generator/MCU_NRST: C1127.1, J1101.10, R1126.1, U1112.7 (NRST)
/Function generator/MCU_NSS: U1112.50 (PA15,JTDI,TIM2_CH1,TIM2_ETR,SPI1_NSS,I2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); also elsewhere on the board
/Function generator/MCU_SCLK: U1112.51 (PC10,DFSDM2_CKIN5,SPI3_SCK,I2S3_CK,USAR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); also elsewhere on the board
/Function generator/TCK_SWCLK: J1101.4, U1112.49 (PA14,TCK-SWCLK,EVENTOUT)
/Function generator/TMS_SWDIO: J1101.2, U1112.46 (PA13,TMS-SWDIO,EVENTOUT)
/Function generator/VDDA: C1152.1, FB1101.1, U1112.13 (VDDA)
/Function generator/V_AMPL: C1120.1, R1105.1, R1107.2, R1114.1, U1107.2 (REFIN)
/Function generator/V_OFFSET: C1123.1, R1112.2, R1124.1, U1108.7
unnamed: C1101.1, R1104.2, U1104.8 (RFB), U1105.6
unnamed: C1101.2, U1104.1 (IOUT), U1105.2 (-)
unnamed: C1102.2, U1107.16 (COMP)
unnamed: C1103.1, C1104.2, C1112.1, L1101.2, L1102.1
unnamed: C1103.2, C1111.1, L1101.1, R1108.1, U1107.14 (IOUT)
unnamed: C1104.1, C1105.2, C1113.1, L1102.2, L1103.1
unnamed: C1105.1, C1106.2, C1114.1, L1103.2, R1109.1
unnamed: C1106.1, R1106.2
unnamed: C1115.1, R1114.2, U1108.1, U1108.2 (-)
unnamed: C1115.2, R1110.1, R1111.2
unnamed: C1116.2, D1101.1 (K), D1101.5 (A), R1111.1, U1108.3 (+)
unnamed: C1117.1, R1113.1, U1101.1, U1102.6
unnamed: C1117.2, R1104.1, R1112.1, R1113.2, U1102.2 (-)
unnamed: C1118.1, R1117.1, U1107.1 (FSADJ)
unnamed: C1119.1, U1107.3 (REFOUT)
unnamed: C1121.1, R1103.2, R1116.1, U1103.6
unnamed: C1121.2, R1106.1, R1115.1, R1116.2, U1103.2 (-)
unnamed: C1122.1, R1121.1, U1108.5 (+)
unnamed: C1123.2, R1123.1, R1124.2, R1125.1, U1108.6 (-)
unnamed: C1124.1, U1112.6 (PH1,EVENTOUT,OSC_OUT), Y1101.2
unnamed: C1125.1, U1112.5 (PH0,EVENTOUT,OSC_IN), Y1101.1
unnamed: C1126.2, U1112.30 (VCAP_1)
unnamed: D1101.2 (K), D1101.6 (A), R1110.2, U1111.3 (VOUTA)
unnamed: R1102.2, U1101.2
unnamed: R1103.1, U1104.7 (VREF)
unnamed: R1120.1, U1107.6 (MCLK), U1110.4
unnamed: R1120.2, U1109.3 (OUT), U1110.1, U1110.2
unnamed: R1121.2, U1111.7 (VOUTB)
unnamed: R1122.1, U1111.16 (RSTSEL)
unnamed: R1127.1, U1112.60 (BOOT0)
unnamed: R1128.2, U1112.59 (PB7,LPTIM1_IN2,TIM4_CH2,I2C1_SDA,DFSDM2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), U1113.5 (SDA)
unnamed: R1129.2, U1112.58 (PB6,LPTIM1_ETR,TIM4_CH1,I2C1_SCL,DFSDM2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), U1113.6 (SCL)
unnamed: U1112.56 (PB4,TRST,TIM3_CH1,SPI1_MISO,SPI3_MISO,I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), U1113.7 (WP)

Schematic: GPIO.sch

Parts:
C1201, C1202, C1203, C1204, C1205, C1206, C1207, C1208, C1209, C1210, C1211, C1212, C1213, C1214, C1215, C1216, C1217, C1218, C1219, C1220, C1221, C1222, C1223, C1224, C1225, C1226, C1227, C1228, C1229: 100n; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
R1201: 1k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R1202: 10k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
U1201, U1202, U1203, U1204, U1205, U1206, U1207, U1208, U1209, U1210, U1211, U1212, U1213, U1214: SN74LVC1T45DBV; SOT-23-6
U1215: MCP23S17_SO; SOIC-28W_7.5x17.9mm_P1.27mm

Connections:
/Analog/10-100mA: U1204.7; also elsewhere on the board
/Analog/REL2_CTR: U1202.3 (A); also elsewhere on the board
/Analog/~10mA: U1204.3 (A); also elsewhere on the board
/Analog/~10uA: U1204.15; also elsewhere on the board
/Analog/~100mA: U1204.4 (B); also elsewhere on the board
/Analog/~ICLAMP: U1210.3 (A); also elsewhere on the board
/Analog/~IMODE: U1202.15; also elsewhere on the board
/Analog/~VRANGE: U1202.7; also elsewhere on the board
/Control/FDACLO: U1202.4 (B); also elsewhere on the board
/GPIO/MCU_~ICLAMP: U1210.4 (B); also elsewhere on the board
/MCU/SPI1_MISO: U1206.4 (B); also elsewhere on the board
/MCU/SPI1_MOSI: U1201.4 (B); also elsewhere on the board
/MCU/SPI1_NSS: U1205.4 (B); also elsewhere on the board
/MCU/SPI1_SCK: U1203.4 (B); also elsewhere on the board
unnamed: R1201.1, U1210.5 (DIR)
unnamed: U1201.3 (A), U1202.14
unnamed: U1202.9, U1204.14
unnamed: U1202.11, U1203.3 (A), U1204.11
unnamed: U1202.12, U1204.12, U1205.3 (A)
unnamed: U1204.9, U1206.3 (A)

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
Board: 6 copper layers, 160.0 x 100.0 mm, 520 parts (149 on the bottom side), 372 nets.

Other parts of the board:
C301, C302, C303, C304, C305, C306, C307: 100n; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
J801: Conn_02x06_Odd_Even; PinHeader_2x06_P2.54mm_Vertical
U301: MT48LC16M16A2P-6A; TSSOP-54

Their connections:
+24VF: J801.1, J801.2, J801.3, J801.4; also elsewhere on the board
/MCU/A0: U301.23; also elsewhere on the board
/MCU/A1: U301.24; also elsewhere on the board
/MCU/A2: U301.25; also elsewhere on the board
/MCU/A3: U301.26; also elsewhere on the board
/MCU/A4: U301.29; also elsewhere on the board
/MCU/A5: U301.30; also elsewhere on the board
/MCU/A6: U301.31; also elsewhere on the board
/MCU/A7: U301.32; also elsewhere on the board
/MCU/A8: U301.33; also elsewhere on the board
/MCU/A9: U301.34; also elsewhere on the board
/MCU/A10: U301.22; also elsewhere on the board
/MCU/A11: U301.35; also elsewhere on the board
/MCU/A12: U301.36; also elsewhere on the board
/MCU/BA0: U301.20; also elsewhere on the board
/MCU/BA1: U301.21; also elsewhere on the board
/MCU/CKE: U301.37; also elsewhere on the board
/MCU/CLK: U301.38; also elsewhere on the board
/MCU/D0: U301.2; also elsewhere on the board
/MCU/D1: U301.4; also elsewhere on the board
/MCU/D2: U301.5; also elsewhere on the board
/MCU/D3: U301.7; also elsewhere on the board
/MCU/D4: U301.8; also elsewhere on the board
/MCU/D5: U301.10; also elsewhere on the board
/MCU/D6: U301.11; also elsewhere on the board
/MCU/D7: U301.13; also elsewhere on the board
/MCU/D8: U301.42; also elsewhere on the board
/MCU/D9: U301.44; also elsewhere on the board
/MCU/D10: U301.45; also elsewhere on the board
/MCU/D11: U301.47; also elsewhere on the board
/MCU/D12: U301.48; also elsewhere on the board
/MCU/D13: U301.50; also elsewhere on the board
/MCU/D14: U301.51; also elsewhere on the board
/MCU/D15: U301.53; also elsewhere on the board
/MCU/LDQM: U301.15; also elsewhere on the board
/MCU/UDQM: U301.39; also elsewhere on the board
/MCU/~CAS: U301.17; also elsewhere on the board
/MCU/~CS: U301.19; also elsewhere on the board
/MCU/~RAS: U301.18; also elsewhere on the board
/MCU/~WE: U301.16; also elsewhere on the board
